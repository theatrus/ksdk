# Keil uVision project ksdk_ucosiii_lib.uvprojx, settings and files
target ksdk_ucosiii_lib Debug (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_UCOSIII, USB_KW40Z, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView;../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/RealView;../../../../rtos;../../../../rtos/uCOSIII/src/config;../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../rtos/uCOSIII/src/uC-LIB;../../../../rtos/uCOSIII/src/uC-CPU;../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKW40Z4/include;../../../../platform/devices/MKW40Z4/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../platform/osa/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
    ../../../../platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group platform-clock-system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MKW40Z4/: fsl_clock_MKW40Z4.c fsl_clock_MKW40Z4.h
  group platform-interrupt-system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-cmp-hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cmt-hal
    ../../../../platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../../../platform/hal/inc/: fsl_cmt_hal.h
  group platform-cmt-drivers
    ../../../../platform/drivers/src/cmt/: fsl_cmt_driver.c fsl_cmt_common.c
    ../../../../platform/drivers/inc/: fsl_cmt_driver.h
  group platform-cop-hal
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform-cop-drivers
    ../../../../platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../platform/drivers/inc/: fsl_cop_driver.h
  group platform-dac-hal
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../platform/drivers/inc/: fsl_dac_driver.h
  group platform-dma-hal
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform-dma-drivers
    ../../../../platform/drivers/src/dma/: fsl_dma_driver.c fsl_dma_common.c
    ../../../../platform/drivers/inc/: fsl_dma_driver.h fsl_dma_request.h
  group platform-dmamux-hal
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-dspi-hal
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform-dspi-drivers
    ../../../../platform/drivers/src/dspi/: fsl_dspi_shared_function.c fsl_dspi_common.c
    ../../../../platform/drivers/inc/: fsl_dspi_shared_function.h
  group platform-dspi-drivers-master
    ../../../../platform/drivers/inc/: fsl_dspi_master_driver.h fsl_dspi_dma_master_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_master_driver.c fsl_dspi_dma_master_driver.c
  group platform-dspi-drivers-slave
    ../../../../platform/drivers/inc/: fsl_dspi_slave_driver.h fsl_dspi_dma_slave_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_slave_driver.c fsl_dspi_dma_slave_driver.c
  group platform-gpio-hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-ltc-hal
    ../../../../platform/hal/src/ltc/: fsl_ltc_hal.c
    ../../../../platform/hal/inc/: fsl_ltc_hal.h
  group platform-ltc-drivers
    ../../../../platform/drivers/inc/: fsl_ltc_driver.h fsl_ltc_driver_aes.h fsl_ltc_driver_hash.h fsl_ltc_driver_prv.h
    ../../../../platform/drivers/src/ltc/: fsl_ltc_driver.c fsl_ltc_driver_aes.c fsl_ltc_driver_aes_ccm.c fsl_ltc_driver_hash.c fsl_ltc_common.c
  group platform-trng-hal
    ../../../../platform/hal/src/trng/: fsl_trng_hal.c
    ../../../../platform/hal/inc/: fsl_trng_hal.h
  group platform-trng-drivers
    ../../../../platform/drivers/src/trng/: fsl_trng_common.c fsl_trng_driver.c
    ../../../../platform/drivers/inc/: fsl_trng_driver.h
  group platform-lpuart-hal
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../platform/drivers/inc/: fsl_lpuart_driver.h fsl_lpuart_dma_driver.h
    ../../../../platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c fsl_lpuart_dma_driver.c
  group platform-mcg-hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-pit-hal
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../platform/drivers/inc/: fsl_rtc_driver.h
  group platform-sim-hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
    ../../../../platform/hal/src/sim/MKW40Z4/: fsl_sim_hal_MKW40Z4.c fsl_sim_hal_MKW40Z4.h
  group platform-smc-hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-tpm-hal
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-tpm-drivers
    ../../../../platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../platform/drivers/inc/: fsl_tpm_driver.h
  group platform-tsi-hal
    ../../../../platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform-tsi-drivers
    ../../../../platform/drivers/src/tsi/: fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v4_driver_specific.c
    ../../../../platform/drivers/inc/: fsl_tsi_driver.h
target ksdk_ucosiii_lib Release (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_UCOSIII, USB_KW40Z, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
