# Keil uVision project ksdk_ucosiii_lib.uvprojx, settings and files
target ksdk_ucosiii_lib Debug (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV46F256VLL15, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../rtos;../../../../rtos/uCOSIII/src/config;../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../rtos/uCOSIII/src/uC-LIB;../../../../rtos/uCOSIII/src/uC-CPU;../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKV46F15/include;../../../../platform/devices/MKV46F15/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../platform/osa/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
    ../../../../platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group platform-clock-system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MKV46F15/: fsl_clock_MKV46F15.c fsl_clock_MKV46F15.h
  group platform-interrupt-system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../platform/system/inc/: fsl_power_manager.h
  group platform-flexcan-hal
    ../../../../platform/hal/src/flexcan/: fsl_flexcan_hal.c
    ../../../../platform/hal/inc/: fsl_flexcan_hal.h
  group platform-flexcan-drivers
    ../../../../platform/drivers/src/flexcan/: fsl_flexcan_driver.c fsl_flexcan_common.c
    ../../../../platform/drivers/inc/: fsl_flexcan_driver.h
  group platform-cmp-hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform-crc-hal
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-crc-drivers
    ../../../../platform/drivers/src/crc/: fsl_crc_driver.c fsl_crc_common.c
    ../../../../platform/drivers/inc/: fsl_crc_driver.h
  group platform-dac-hal
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../platform/drivers/inc/: fsl_dac_driver.h
  group platform-dmamux-hal
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-edma-hal
    ../../../../platform/hal/inc/: fsl_edma_hal.h
    ../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group platform-edma-drivers
    ../../../../platform/drivers/inc/: fsl_edma_driver.h fsl_edma_request.h
    ../../../../platform/drivers/src/edma/: fsl_edma_driver.c fsl_edma_common.c
  group platform-dspi-hal
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform-dspi-drivers
    ../../../../platform/drivers/src/dspi/: fsl_dspi_shared_function.c fsl_dspi_common.c fsl_dspi_edma_shared_function.c
    ../../../../platform/drivers/inc/: fsl_dspi_shared_function.h fsl_dspi_edma_shared_function.h
  group platform-dspi-drivers-master
    ../../../../platform/drivers/inc/: fsl_dspi_master_driver.h fsl_dspi_edma_master_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_master_driver.c fsl_dspi_edma_master_driver.c
  group platform-dspi-drivers-slave
    ../../../../platform/drivers/inc/: fsl_dspi_slave_driver.h fsl_dspi_edma_slave_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_slave_driver.c fsl_dspi_edma_slave_driver.c
  group platform-ftm-hal
    ../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../platform/hal/inc/: fsl_ftm_hal.h
  group platform-ftm-drivers
    ../../../../platform/drivers/src/ftm/: fsl_ftm_driver.c fsl_ftm_common.c
    ../../../../platform/drivers/inc/: fsl_ftm_driver.h
  group platform-gpio-hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-ewm-hal
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-ewm-drivers
    ../../../../platform/drivers/inc/: fsl_ewm_driver.h
    ../../../../platform/drivers/src/ewm/: fsl_ewm_driver.c fsl_ewm_common.c
  group platform-mcg-hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-osc-hal
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-pdb-hal
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-pdb-drivers
    ../../../../platform/drivers/src/pdb/: fsl_pdb_driver.c fsl_pdb_common.c
    ../../../../platform/drivers/inc/: fsl_pdb_driver.h
  group platform-pit-hal
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-sim-hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
    ../../../../platform/hal/src/sim/MKV46F15/: fsl_sim_hal_MKV46F15.c fsl_sim_hal_MKV46F15.h
  group platform-smc-hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-uart-hal
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform-uart-drivers
    ../../../../platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_edma_driver.c
    ../../../../platform/drivers/inc/: fsl_uart_driver.h fsl_uart_edma_driver.h
  group platform-wdog-hal
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-wdog-drivers
    ../../../../platform/drivers/src/wdog/: fsl_wdog_driver.c fsl_wdog_common.c
    ../../../../platform/drivers/inc/: fsl_wdog_driver.h
  group platform-xbar-hal
    ../../../../platform/hal/src/xbar/: fsl_xbar_hal.c
    ../../../../platform/hal/inc/: fsl_xbar_hal.h fsl_xbar_signals.h
  group platform-xbar-drivers
    ../../../../platform/drivers/src/xbar/: fsl_xbar_driver.c fsl_xbar_common.c
    ../../../../platform/drivers/inc/: fsl_xbar_driver.h
  group platform-aoi-hal
    ../../../../platform/hal/src/aoi/: fsl_aoi_hal.c
    ../../../../platform/hal/inc/: fsl_aoi_hal.h
  group platform-aoi-drivers
    ../../../../platform/drivers/src/aoi/: fsl_aoi_driver.c fsl_aoi_common.c
    ../../../../platform/drivers/inc/: fsl_aoi_driver.h
  group platform-cadc-hal
    ../../../../platform/hal/src/cyclicAdc/: fsl_cadc_hal.c
    ../../../../platform/hal/inc/: fsl_cadc_hal.h
  group platform-cadc-drivers
    ../../../../platform/drivers/src/cyclicAdc/: fsl_cadc_driver.c fsl_cadc_common.c
    ../../../../platform/drivers/inc/: fsl_cadc_driver.h
  group platform-enc-hal
    ../../../../platform/hal/src/enc/: fsl_enc_hal.c
    ../../../../platform/hal/inc/: fsl_enc_hal.h
  group platform-enc-drivers
    ../../../../platform/drivers/inc/: fsl_enc_driver.h
    ../../../../platform/drivers/src/enc/: fsl_enc_common.c fsl_enc_driver.c
  group platform-pwm-hal
    ../../../../platform/hal/src/pwm/: fsl_pwm_hal.c
    ../../../../platform/hal/inc/: fsl_pwm_hal.h
  group platform-pwm-drivers
    ../../../../platform/drivers/src/pwm/: fsl_pwm_driver.c fsl_pwm_common.c
    ../../../../platform/drivers/inc/: fsl_pwm_driver.h
target ksdk_ucosiii_lib Release (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKV46F256VLL15, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
