# Keil uVision project ksdk_ucosiii_lib.uvprojx, settings and files
target ksdk_ucosiii_lib Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../rtos;../../../../rtos/uCOSIII/src/config;../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../rtos/uCOSIII/src/uC-LIB;../../../../rtos/uCOSIII/src/uC-CPU;../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MK80F25615/include;../../../../platform/devices/MK80F25615/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../platform/osa/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
    ../../../../platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group platform-clock-system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MK80F25615/: fsl_clock_MK80F25615.c fsl_clock_MK80F25615.h
  group platform-interrupt-system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-flexbus-hal
    ../../../../platform/hal/src/flexbus/: fsl_flexbus_hal.c
    ../../../../platform/hal/inc/: fsl_flexbus_hal.h
  group platform-flexbus-drivers
    ../../../../platform/drivers/src/flexbus/: fsl_flexbus_driver.c
    ../../../../platform/drivers/inc/: fsl_flexbus_driver.h
  group platform-flexbus
    ../../../../platform/drivers/src/flexbus/: fsl_flexbus_common.c
  group platform-cmp-hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cmt-hal
    ../../../../platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../../../platform/hal/inc/: fsl_cmt_hal.h
  group platform-cmt-drivers
    ../../../../platform/drivers/src/cmt/: fsl_cmt_driver.c fsl_cmt_common.c
    ../../../../platform/drivers/inc/: fsl_cmt_driver.h
  group platform-crc-hal
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-crc-drivers
    ../../../../platform/drivers/src/crc/: fsl_crc_driver.c fsl_crc_common.c
    ../../../../platform/drivers/inc/: fsl_crc_driver.h
  group platform-dac-hal
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../platform/drivers/inc/: fsl_dac_driver.h
  group platform-dmamux-hal
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-edma-hal
    ../../../../platform/hal/inc/: fsl_edma_hal.h
    ../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group platform-edma-drivers
    ../../../../platform/drivers/inc/: fsl_edma_driver.h fsl_edma_request.h
    ../../../../platform/drivers/src/edma/: fsl_edma_driver.c fsl_edma_common.c
  group platform-emvsim-hal
    ../../../../platform/hal/inc/: fsl_emvsim_hal.h
    ../../../../platform/hal/src/emvsim/: fsl_emvsim_hal.c
  group platform-dspi-hal
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform-dspi-drivers
    ../../../../platform/drivers/src/dspi/: fsl_dspi_shared_function.c fsl_dspi_common.c fsl_dspi_edma_shared_function.c
    ../../../../platform/drivers/inc/: fsl_dspi_shared_function.h fsl_dspi_edma_shared_function.h
  group platform-dspi-drivers-master
    ../../../../platform/drivers/inc/: fsl_dspi_master_driver.h fsl_dspi_edma_master_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_master_driver.c fsl_dspi_edma_master_driver.c
  group platform-dspi-drivers-slave
    ../../../../platform/drivers/inc/: fsl_dspi_slave_driver.h fsl_dspi_edma_slave_driver.h
    ../../../../platform/drivers/src/dspi/: fsl_dspi_slave_driver.c fsl_dspi_edma_slave_driver.c
  group platform-ftm-hal
    ../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../platform/hal/inc/: fsl_ftm_hal.h
  group platform-ftm-drivers
    ../../../../platform/drivers/src/ftm/: fsl_ftm_driver.c fsl_ftm_common.c
    ../../../../platform/drivers/inc/: fsl_ftm_driver.h
  group platform-flexio-hal
    ../../../../platform/hal/src/flexio/: fsl_flexio_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_hal.h
  group platform-flexio-hal-uart
    ../../../../platform/hal/src/flexio/: fsl_flexio_uart_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_uart_hal.h
  group platform-flexio-hal-spi
    ../../../../platform/hal/src/flexio/: fsl_flexio_spi_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_spi_hal.h
  group platform-flexio-hal-i2s
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2s_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2s_hal.h
  group platform-flexio-hal-i2c
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2c_hal.h
  group platform-flexio-drivers
    ../../../../platform/drivers/src/flexio/: fsl_flexio_driver.c fsl_flexio_common.c
    ../../../../platform/drivers/inc/: fsl_flexio_driver.h
  group platform-flexio-drivers-uart
    ../../../../platform/drivers/src/flexio/: fsl_flexio_uart_driver.c fsl_flexio_uart_edma_driver.c
    ../../../../platform/drivers/inc/: fsl_flexio_uart_driver.h fsl_flexio_uart_share.h fsl_flexio_uart_edma_driver.h
  group platform-flexio-drivers-i2s
    ../../../../platform/drivers/src/flexio/: fsl_flexio_i2s_driver.c
    ../../../../platform/drivers/inc/: fsl_flexio_i2s_driver.h
  group platform-flexio-drivers-spi
    ../../../../platform/drivers/src/flexio/: fsl_flexio_spi_driver.c
    ../../../../platform/drivers/inc/: fsl_flexio_spi_driver.h
  group platform-flexio-drivers-i2c
    ../../../../platform/drivers/src/flexio/: fsl_flexio_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_flexio_i2c_master_driver.h
  group platform-flexio-hal-camera
    ../../../../platform/hal/src/flexio/: fsl_flexio_camera_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_camera_hal.h
  group platform-flexio-drivers-camera
    ../../../../platform/drivers/src/flexio/: fsl_flexio_camera_edma_driver.c
    ../../../../platform/drivers/inc/: fsl_flexio_camera_edma_driver.h
  group platform-gpio-hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-lmem-hal
    ../../../../platform/hal/src/lmem/: fsl_lmem_cache_hal.c
    ../../../../platform/hal/inc/: fsl_lmem_cache_hal.h
  group platform-lmem-drivers
    ../../../../platform/drivers/src/lmem/: fsl_lmem_common.c fsl_lmem_cache_driver.c
    ../../../../platform/drivers/inc/: fsl_lmem_cache_driver.h
  group platform-lptmr-hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-mpu-hal
    ../../../../platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../../../platform/hal/inc/: fsl_mpu_hal.h
  group platform-mpu-drivers
    ../../../../platform/drivers/inc/: fsl_mpu_driver.h
    ../../../../platform/drivers/src/mpu/: fsl_mpu_driver.c fsl_mpu_common.c
  group platform-ewm-hal
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-ewm-drivers
    ../../../../platform/drivers/inc/: fsl_ewm_driver.h
    ../../../../platform/drivers/src/ewm/: fsl_ewm_driver.c fsl_ewm_common.c
  group platform-trng-hal
    ../../../../platform/hal/src/trng/: fsl_trng_hal.c
    ../../../../platform/hal/inc/: fsl_trng_hal.h
  group platform-trng-drivers
    ../../../../platform/drivers/src/trng/: fsl_trng_common.c fsl_trng_driver.c
    ../../../../platform/drivers/inc/: fsl_trng_driver.h
  group platform-lpuart-hal
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../platform/drivers/inc/: fsl_lpuart_driver.h fsl_lpuart_edma_driver.h
    ../../../../platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c fsl_lpuart_edma_driver.c
  group platform-mcg-hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-osc-hal
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-pdb-hal
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-pdb-drivers
    ../../../../platform/drivers/src/pdb/: fsl_pdb_driver.c fsl_pdb_common.c
    ../../../../platform/drivers/inc/: fsl_pdb_driver.h
  group platform-pit-hal
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../platform/drivers/inc/: fsl_rtc_driver.h
  group platform-sai-hal
    ../../../../platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../platform/hal/inc/: fsl_sai_hal.h
  group platform-sai-drivers
    ../../../../platform/drivers/src/sai/: fsl_sai_driver.c fsl_sai_common.c
    ../../../../platform/drivers/inc/: fsl_sai_driver.h
  group platform-sdhc-hal
    ../../../../platform/hal/inc/: fsl_sdhc_hal.h
    ../../../../platform/hal/src/sdhc/: fsl_sdhc_hal.c
  group platform-sdhc-drivers
    ../../../../platform/drivers/src/sdhc/: fsl_sdhc_driver.c fsl_sdhc_common.c
    ../../../../platform/drivers/inc/: fsl_sdhc_driver.h fsl_sdhc.h
    ../../../../platform/composite/inc/: fsl_sdmmc_card.h
  group platform-sim-hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
    ../../../../platform/hal/src/sim/MK80F25615/: fsl_sim_hal_MK80F25615.c fsl_sim_hal_MK80F25615.h
  group platform-smartcard-drivers
    ../../../../platform/drivers/src/smartcard/: fsl_smartcard_common.c fsl_smartcard_driver.c fsl_smartcard_emvsim_driver.c
    ../../../../platform/drivers/inc/: fsl_smartcard_driver.h fsl_smartcard_emvsim_driver.h
    ../../../../platform/drivers/src/smartcard/interface/: fsl_smartcard_direct_driver.c fsl_smartcard_direct_driver.h
  group platform-smc-hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-tpm-hal
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-tpm-drivers
    ../../../../platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../platform/drivers/inc/: fsl_tpm_driver.h
  group platform-tsi-hal
    ../../../../platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform-tsi-drivers
    ../../../../platform/drivers/src/tsi/: fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v4_driver_specific.c
    ../../../../platform/drivers/inc/: fsl_tsi_driver.h
  group platform-wdog-hal
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-wdog-drivers
    ../../../../platform/drivers/src/wdog/: fsl_wdog_driver.c fsl_wdog_common.c
    ../../../../platform/drivers/inc/: fsl_wdog_driver.h
  group platform-vref-hal
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
  group platform-vref-drivers
    ../../../../platform/drivers/inc/: fsl_vref_driver.h
    ../../../../platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
  group platform-qspi-hal
    ../../../../platform/hal/src/qspi/: fsl_qspi_hal.c
    ../../../../platform/hal/inc/: fsl_qspi_hal.h
  group platform-qspi-drivers
    ../../../../platform/drivers/src/qspi/: fsl_qspi_driver.c fsl_qspi_common.c
    ../../../../platform/drivers/inc/: fsl_qspi_driver.h
  group platform-sdramc-hal
    ../../../../platform/hal/src/sdramc/: fsl_sdramc_hal.c
    ../../../../platform/hal/inc/: fsl_sdramc_hal.h
  group platform-sdramc-drivers
    ../../../../platform/drivers/src/sdramc/: fsl_sdramc_driver.c fsl_sdramc_common.c
    ../../../../platform/drivers/inc/: fsl_sdramc_driver.h
target ksdk_ucosiii_lib Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: libksdk_platform_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK80FN256VDC15, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
