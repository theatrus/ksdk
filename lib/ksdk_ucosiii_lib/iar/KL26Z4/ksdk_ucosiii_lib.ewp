# IAR project ksdk_ucosiii_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL26Z128VLH4; FSL_RTOS_UCOSIII
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR; ../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/IAR; ../../../../rtos; ../../../../rtos/uCOSIII/src/config; ../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../rtos/uCOSIII/src/uC-LIB; ../../../../rtos/uCOSIII/src/uC-CPU; ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKL26Z4/include; ../../../../platform/devices/MKL26Z4/startup; ../../../../platform/utilities/inc; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/system/inc; ../../../../platform/osa/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL26Z128VLH4; FSL_RTOS_UCOSIII
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
    ../../../../platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group platform/clock/system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MKL26Z4/: fsl_clock_MKL26Z4.c fsl_clock_MKL26Z4.h
  group platform/interrupt/system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform/hwtimer/system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform/power/system
    ../../../../platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../platform/system/inc/: fsl_power_manager.h
  group platform/adc16/hal
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/adc16/drivers
    ../../../../platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform/cmp/hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/cmp/drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform/cop/hal
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform/cop/drivers
    ../../../../platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../platform/drivers/inc/: fsl_cop_driver.h
  group platform/dac/hal
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform/dac/drivers
    ../../../../platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../platform/drivers/inc/: fsl_dac_driver.h
  group platform/dma/hal
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform/dma/drivers
    ../../../../platform/drivers/src/dma/: fsl_dma_driver.c fsl_dma_common.c
    ../../../../platform/drivers/inc/: fsl_dma_driver.h fsl_dma_request.h
  group platform/dmamux/hal
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform/gpio/hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/gpio/drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform/i2c/hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/i2c/drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform/i2c/drivers/master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform/i2c/drivers/slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform/llwu/hal
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform/lpsci/hal
    ../../../../platform/hal/inc/: fsl_lpsci_hal.h
    ../../../../platform/hal/src/lpsci/: fsl_lpsci_hal.c
  group platform/lpsci/drivers
    ../../../../platform/drivers/src/lpsci/: fsl_lpsci_common.c fsl_lpsci_driver.c fsl_lpsci_dma_driver.c
    ../../../../platform/drivers/inc/: fsl_lpsci_driver.h fsl_lpsci_dma_driver.h
  group platform/lptmr/hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/lptmr/drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform/mcg/hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform/osc/hal
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/pit/hal
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform/pit/drivers
    ../../../../platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../platform/drivers/inc/: fsl_pit_driver.h
  group platform/port/hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/rtc/hal
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform/rtc/drivers
    ../../../../platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../platform/drivers/inc/: fsl_rtc_driver.h
  group platform/sai/hal
    ../../../../platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../platform/hal/inc/: fsl_sai_hal.h
  group platform/sai/drivers
    ../../../../platform/drivers/src/sai/: fsl_sai_driver.c fsl_sai_common.c
    ../../../../platform/drivers/inc/: fsl_sai_driver.h
  group platform/sim/hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
    ../../../../platform/hal/src/sim/MKL26Z4/: fsl_sim_hal_MKL26Z4.c fsl_sim_hal_MKL26Z4.h
  group platform/spi/hal
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform/spi/drivers
    ../../../../platform/drivers/src/spi/: fsl_spi_shared_function.c fsl_spi_common.c fsl_spi_dma_shared_function.c
    ../../../../platform/drivers/inc/: fsl_spi_shared_function.h fsl_spi_dma_shared_function.h
  group platform/spi/drivers/master
    ../../../../platform/drivers/src/spi/: fsl_spi_master_driver.c fsl_spi_dma_master_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_master_driver.h fsl_spi_dma_master_driver.h
  group platform/spi/drivers/slave
    ../../../../platform/drivers/src/spi/: fsl_spi_slave_driver.c fsl_spi_dma_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_slave_driver.h fsl_spi_dma_slave_driver.h
  group platform/smc/hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/pmc/hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/rcm/hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform/tpm/hal
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform/tpm/drivers
    ../../../../platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../platform/drivers/inc/: fsl_tpm_driver.h
  group platform/tsi/hal
    ../../../../platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform/tsi/drivers
    ../../../../platform/drivers/src/tsi/: fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v4_driver_specific.c
    ../../../../platform/drivers/inc/: fsl_tsi_driver.h
  group platform/uart/hal
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform/uart/drivers
    ../../../../platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_dma_driver.c
    ../../../../platform/drivers/inc/: fsl_uart_driver.h fsl_uart_dma_driver.h
