# Keil uVision project ksdk_platform_lib.uvprojx, settings and files
target ksdk_platform_lib Debug (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKM34Z256VLQ7
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKM34Z7/include;../../../../platform/devices/MKM34Z7/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../platform/osa/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../platform/osa/src/: fsl_os_abstraction_bm.c
  group platform-clock-system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MKM34Z7/: fsl_clock_MKM34Z7.c fsl_clock_MKM34Z7.h
  group platform-interrupt-system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../platform/system/inc/: fsl_power_manager.h
  group platform-irtc-hal
    ../../../../platform/hal/src/irtc/: fsl_irtc_hal.c
    ../../../../platform/hal/inc/: fsl_irtc_hal.h
  group platform-irtc-drivers
    ../../../../platform/drivers/src/irtc/: fsl_irtc_driver.c fsl_irtc_common.c
    ../../../../platform/drivers/inc/: fsl_irtc_driver.h
  group platform-adc16-hal
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-afe-hal
    ../../../../platform/hal/src/afe/: fsl_afe_hal.c
    ../../../../platform/hal/inc/: fsl_afe_hal.h
  group platform-afe-drivers
    ../../../../platform/drivers/inc/: fsl_afe_driver.h
    ../../../../platform/drivers/src/afe/: fsl_afe_driver.c fsl_afe_common.c
  group platform-cmp-hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform-crc-hal
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-crc-drivers
    ../../../../platform/drivers/src/crc/: fsl_crc_driver.c fsl_crc_common.c
    ../../../../platform/drivers/inc/: fsl_crc_driver.h
  group platform-dma-hal
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform-dma-drivers
    ../../../../platform/drivers/src/dma/: fsl_dma_driver.c fsl_dma_common.c
    ../../../../platform/drivers/inc/: fsl_dma_driver.h fsl_dma_request.h
  group platform-dmamux-hal
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-gpio-hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-mmau-hal
    ../../../../platform/hal/src/mmau/: fsl_mmau_hal.c
    ../../../../platform/hal/inc/: fsl_mmau_hal.h fsl_mmau_ins.h
  group platform-mmau-drivers
    ../../../../platform/drivers/inc/: fsl_mmau_driver.h
    ../../../../platform/drivers/src/mmau/: fsl_mmau_driver.c fsl_mmau_common.c
  group platform-mpu-hal
    ../../../../platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../../../platform/hal/inc/: fsl_mpu_hal.h
  group platform-mpu-drivers
    ../../../../platform/drivers/inc/: fsl_mpu_driver.h
    ../../../../platform/drivers/src/mpu/: fsl_mpu_driver.c fsl_mpu_common.c
  group platform-ewm-hal
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-ewm-drivers
    ../../../../platform/drivers/inc/: fsl_ewm_driver.h
    ../../../../platform/drivers/src/ewm/: fsl_ewm_driver.c fsl_ewm_common.c
  group platform-slcd-hal
    ../../../../platform/hal/src/slcd/: fsl_slcd_hal.c
    ../../../../platform/hal/inc/: fsl_slcd_hal.h
  group platform-slcd-drivers
    ../../../../platform/drivers/inc/: fsl_slcd_driver.h
    ../../../../platform/drivers/src/slcd/: fsl_slcd_driver.c fsl_slcd_common.c
  group platform-lpuart-hal
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../platform/drivers/inc/: fsl_lpuart_driver.h fsl_lpuart_dma_driver.h
    ../../../../platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c fsl_lpuart_dma_driver.c
  group platform-mcg-hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-osc-hal
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-pdb-hal
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-pdb-drivers
    ../../../../platform/drivers/src/pdb/: fsl_pdb_driver.c fsl_pdb_common.c
    ../../../../platform/drivers/inc/: fsl_pdb_driver.h
  group platform-pit-hal
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-quadtmr-hal
    ../../../../platform/hal/src/quadtmr/: fsl_quadtmr_hal.c
    ../../../../platform/hal/inc/: fsl_quadtmr_hal.h
  group platform-quadtmr-drivers
    ../../../../platform/drivers/src/quadtmr/: fsl_quadtmr_driver.c fsl_quadtmr_common.c
    ../../../../platform/drivers/inc/: fsl_quadtmr_driver.h
  group platform-rnga-hal
    ../../../../platform/hal/src/rnga/: fsl_rnga_hal.c
    ../../../../platform/hal/inc/: fsl_rnga_hal.h
  group platform-rnga-drivers
    ../../../../platform/drivers/src/rnga/: fsl_rnga_driver.c fsl_rnga_common.c
    ../../../../platform/drivers/inc/: fsl_rnga_driver.h
  group platform-sim-hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
    ../../../../platform/hal/src/sim/MKM34Z7/: fsl_sim_hal_MKM34Z7.c fsl_sim_hal_MKM34Z7.h
  group platform-smartcard-drivers
    ../../../../platform/drivers/src/smartcard/: fsl_smartcard_common.c fsl_smartcard_driver.c fsl_smartcard_uart_driver.c
    ../../../../platform/drivers/inc/: fsl_smartcard_driver.h fsl_smartcard_uart_driver.h
    ../../../../platform/drivers/src/smartcard/interface/: fsl_smartcard_ncn8025_driver.c
  group platform-spi-hal
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform-spi-drivers
    ../../../../platform/drivers/src/spi/: fsl_spi_shared_function.c fsl_spi_common.c fsl_spi_dma_shared_function.c
    ../../../../platform/drivers/inc/: fsl_spi_shared_function.h fsl_spi_dma_shared_function.h
  group platform-spi-drivers-master
    ../../../../platform/drivers/src/spi/: fsl_spi_master_driver.c fsl_spi_dma_master_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_master_driver.h fsl_spi_dma_master_driver.h
  group platform-spi-drivers-slave
    ../../../../platform/drivers/src/spi/: fsl_spi_slave_driver.c fsl_spi_dma_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_slave_driver.h fsl_spi_dma_slave_driver.h
  group platform-smc-hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-uart-hal
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform-uart-drivers
    ../../../../platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_dma_driver.c
    ../../../../platform/drivers/inc/: fsl_uart_driver.h fsl_uart_dma_driver.h
  group platform-wdog-hal
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-wdog-drivers
    ../../../../platform/drivers/src/wdog/: fsl_wdog_driver.c fsl_wdog_common.c
    ../../../../platform/drivers/inc/: fsl_wdog_driver.h
  group platform-vref-hal
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
  group platform-vref-drivers
    ../../../../platform/drivers/inc/: fsl_vref_driver.h
    ../../../../platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
  group platform-xbar-hal
    ../../../../platform/hal/src/xbar/: fsl_xbar_hal.c
    ../../../../platform/hal/inc/: fsl_xbar_hal.h fsl_xbar_signals.h
  group platform-xbar-drivers
    ../../../../platform/drivers/src/xbar/: fsl_xbar_driver.c fsl_xbar_common.c
    ../../../../platform/drivers/inc/: fsl_xbar_driver.h
target ksdk_platform_lib Release (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKM34Z256VLQ7
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
