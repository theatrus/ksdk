# IAR project ksdk_platform_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL02Z32xxx4 Freescale MKL02Z32xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL02Z32VFM4; FRDM_KL02Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKL02Z4/include; ../../../../platform/devices/MKL02Z4/startup; ../../../../platform/utilities/inc; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/system/inc; ../../../../platform/osa/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL02Z32VFM4; FRDM_KL02Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group osa
    ../../../../platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../platform/osa/src/: fsl_os_abstraction_bm.c
  group platform/clock/system
    ../../../../platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../platform/system/inc/: fsl_clock_manager.h
    ../../../../platform/system/src/clock/MKL02Z4/: fsl_clock_MKL02Z4.c fsl_clock_MKL02Z4.h
  group platform/interrupt/system
    ../../../../platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../platform/system/inc/: fsl_interrupt_manager.h
  group platform/hwtimer/system
    ../../../../platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_systick.c
    ../../../../platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_systick.h
  group platform/adc16/hal
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/adc16/drivers
    ../../../../platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform/cmp/hal
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/cmp/drivers
    ../../../../platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../platform/drivers/inc/: fsl_cmp_driver.h
  group platform/cop/hal
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform/cop/drivers
    ../../../../platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../platform/drivers/inc/: fsl_cop_driver.h
  group platform/gpio/hal
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/gpio/drivers
    ../../../../platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../platform/drivers/inc/: fsl_gpio_driver.h
  group platform/i2c/hal
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/i2c/drivers
    ../../../../platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform/i2c/drivers/master
    ../../../../platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform/i2c/drivers/slave
    ../../../../platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform/lpsci/hal
    ../../../../platform/hal/inc/: fsl_lpsci_hal.h
    ../../../../platform/hal/src/lpsci/: fsl_lpsci_hal.c
  group platform/lpsci/drivers
    ../../../../platform/drivers/src/lpsci/: fsl_lpsci_common.c fsl_lpsci_driver.c
    ../../../../platform/drivers/inc/: fsl_lpsci_driver.h
  group platform/lptmr/hal
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/lptmr/drivers
    ../../../../platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform/mcg/hal
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform/osc/hal
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/port/hal
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/sim/hal
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform/sim/system
    ../../../../platform/hal/src/sim/MKL02Z4/: fsl_sim_hal_MKL02Z4.c fsl_sim_hal_MKL02Z4.h
  group platform/spi/hal
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform/spi/drivers
    ../../../../platform/drivers/src/spi/: fsl_spi_shared_function.c fsl_spi_common.c
    ../../../../platform/drivers/inc/: fsl_spi_shared_function.h
  group platform/spi/drivers/master
    ../../../../platform/drivers/src/spi/: fsl_spi_master_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_master_driver.h
  group platform/spi/drivers/slave
    ../../../../platform/drivers/src/spi/: fsl_spi_slave_driver.c
    ../../../../platform/drivers/inc/: fsl_spi_slave_driver.h
  group platform/smc/hal
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/pmc/hal
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/rcm/hal
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform/tpm/hal
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform/tpm/drivers
    ../../../../platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../platform/drivers/inc/: fsl_tpm_driver.h
