# Keil uVision project ksdk_hal_lib.uvprojx, settings and files
target ksdk_hal_lib Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: libksdk_hal.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MK80F25615/include;../../../../platform/devices/MK80F25615/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group platform-hal-adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform-hal-cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-hal-cmt
    ../../../../platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../../../platform/hal/inc/: fsl_cmt_hal.h
  group platform-hal-crc
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-hal-dac
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform-hal-dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-hal-edma
    ../../../../platform/hal/inc/: fsl_edma_hal.h
    ../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group platform-hal-emvsim
    ../../../../platform/hal/inc/: fsl_emvsim_hal.h
    ../../../../platform/hal/src/emvsim/: fsl_emvsim_hal.c
  group platform-hal-ewm
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-hal-dspi
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform-hal-flexio
    ../../../../platform/hal/src/flexio/: fsl_flexio_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_hal.h
  group platform-hal-flexio-uart
    ../../../../platform/hal/src/flexio/: fsl_flexio_uart_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_uart_hal.h
  group platform-hal-flexio-spi
    ../../../../platform/hal/src/flexio/: fsl_flexio_spi_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_spi_hal.h
  group platform-hal-flexio-i2s
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2s_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2s_hal.h
  group platform-hal-flexio-i2c
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2c_hal.h
  group platform-hal-flexio-camera
    ../../../../platform/hal/src/flexio/: fsl_flexio_camera_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_camera_hal.h
  group platform-hal-ftm
    ../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../platform/hal/inc/: fsl_ftm_hal.h
  group platform-hal-gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-hal-i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-hal-llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-lmem-hal
    ../../../../platform/hal/src/lmem/: fsl_lmem_cache_hal.c
    ../../../../platform/hal/inc/: fsl_lmem_cache_hal.h
  group platform-hal-lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-hal-lpuart
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform-hal-mpu
    ../../../../platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../../../platform/hal/inc/: fsl_mpu_hal.h
  group platform-hal-mcg
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-hal-osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-hal-pdb
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-hal-pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-hal-port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-hal-rtc
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform-hal-sai
    ../../../../platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../platform/hal/inc/: fsl_sai_hal.h
  group platform-hal-sdhc
    ../../../../platform/hal/inc/: fsl_sdhc_hal.h
    ../../../../platform/hal/src/sdhc/: fsl_sdhc_hal.c
  group platform-hal-sim
    ../../../../platform/hal/src/sim/MK80F25615/: fsl_sim_hal_MK80F25615.c
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform-hal-smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-hal-tpm
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-hal-trng
    ../../../../platform/hal/src/trng/: fsl_trng_hal.c
    ../../../../platform/hal/inc/: fsl_trng_hal.h
  group platform-hal-tsi
    ../../../../platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform-hal-wdog
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-hal-pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-hal-rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-hal-vref
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
  group platform-hal-qspi
    ../../../../platform/hal/src/qspi/: fsl_qspi_hal.c
    ../../../../platform/hal/inc/: fsl_qspi_hal.h
  group platform-hal-sdramc
    ../../../../platform/hal/src/sdramc/: fsl_sdramc_hal.c
    ../../../../platform/hal/inc/: fsl_sdramc_hal.h
target ksdk_hal_lib Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: libksdk_hal.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK80FN256VDC15
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
