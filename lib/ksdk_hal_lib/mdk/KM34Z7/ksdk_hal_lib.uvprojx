# Keil uVision project ksdk_hal_lib.uvprojx, settings and files
target ksdk_hal_lib Debug (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: libksdk_hal.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKM34Z256VLQ7
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKM34Z7/include;../../../../platform/devices/MKM34Z7/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group platform-hal-gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-hal-lpuart
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform-hal-port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-hal-uart
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform-hal-mmau
    ../../../../platform/hal/src/mmau/: fsl_mmau_hal.c
    ../../../../platform/hal/inc/: fsl_mmau_hal.h fsl_mmau_ins.h
  group platform-hal-xbar
    ../../../../platform/hal/src/xbar/: fsl_xbar_hal.c
    ../../../../platform/hal/inc/: fsl_xbar_hal.h fsl_xbar_signals.h
  group platform-hal-afe
    ../../../../platform/hal/src/afe/: fsl_afe_hal.c
    ../../../../platform/hal/inc/: fsl_afe_hal.h
  group platform-hal-lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-hal-dma
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform-hal-quadtmr
    ../../../../platform/hal/src/quadtmr/: fsl_quadtmr_hal.c
    ../../../../platform/hal/inc/: fsl_quadtmr_hal.h
  group platform-hal-slcd
    ../../../../platform/hal/src/slcd/: fsl_slcd_hal.c
    ../../../../platform/hal/inc/: fsl_slcd_hal.h
  group platform-hal-adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform-hal-cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-hal-crc
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-hal-dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-hal-ewm
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-hal-i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-hal-llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-hal-mpu
    ../../../../platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../../../platform/hal/inc/: fsl_mpu_hal.h
  group platform-hal-mcg
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-hal-osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-hal-pdb
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-hal-pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-hal-irtc
    ../../../../platform/hal/src/irtc/: fsl_irtc_hal.c
    ../../../../platform/hal/inc/: fsl_irtc_hal.h
  group platform-hal-rnga
    ../../../../platform/hal/src/rnga/: fsl_rnga_hal.c
    ../../../../platform/hal/inc/: fsl_rnga_hal.h
  group platform-hal-sim
    ../../../../platform/hal/src/sim/MKM34Z7/: fsl_sim_hal_MKM34Z7.c
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform-hal-smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-hal-spi
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform-hal-wdog
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-hal-pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-hal-rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform-hal-vref
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
target ksdk_hal_lib Release (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: libksdk_hal.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKM34Z256VLQ7
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
