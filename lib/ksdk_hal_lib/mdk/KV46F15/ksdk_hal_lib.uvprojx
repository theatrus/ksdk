# Keil uVision project ksdk_hal_lib.uvprojx, settings and files
target ksdk_hal_lib Debug (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  output: libksdk_hal.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV46F256VLL15
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/CMSIS/Include;../../../../platform/devices;../../../../platform/devices/MKV46F15/include;../../../../platform/devices/MKV46F15/startup;../../../../platform/utilities/inc;../../../../platform/hal/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group platform-hal-aoi
    ../../../../platform/hal/src/aoi/: fsl_aoi_hal.c
    ../../../../platform/hal/inc/: fsl_aoi_hal.h
  group platform-hal-cadc
    ../../../../platform/hal/src/cyclicAdc/: fsl_cadc_hal.c
    ../../../../platform/hal/inc/: fsl_cadc_hal.h
  group platform-hal-cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform-hal-crc
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform-hal-dac
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform-hal-dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform-hal-edma
    ../../../../platform/hal/inc/: fsl_edma_hal.h
    ../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group platform-hal-ewm
    ../../../../platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../platform/hal/inc/: fsl_ewm_hal.h
  group platform-hal-enc
    ../../../../platform/hal/src/enc/: fsl_enc_hal.c
    ../../../../platform/hal/inc/: fsl_enc_hal.h
  group platform-hal-dspi
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform-hal-flexcan
    ../../../../platform/hal/src/flexcan/: fsl_flexcan_hal.c
    ../../../../platform/hal/inc/: fsl_flexcan_hal.h
  group platform-hal-ftm
    ../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../platform/hal/inc/: fsl_ftm_hal.h
  group platform-hal-gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform-hal-i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform-hal-llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform-hal-lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform-hal-mcg
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-hal-osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform-hal-pdb
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform-hal-pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform-hal-port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform-hal-pwm
    ../../../../platform/hal/src/pwm/: fsl_pwm_hal.c
    ../../../../platform/hal/inc/: fsl_pwm_hal.h
  group platform-hal-sim
    ../../../../platform/hal/src/sim/MKV46F15/: fsl_sim_hal_MKV46F15.c
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform-hal-smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform-hal-uart
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform-hal-wdog
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform-hal-pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform-hal-rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
target ksdk_hal_lib Release (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  output: libksdk_hal.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKV46F256VLL15
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
