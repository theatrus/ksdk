# IAR project ksdk_hal_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL33Z64xxx4 Freescale MKL33Z64xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL33Z64VLH4; FRDM_KL43Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKL33Z644/include; ../../../../platform/devices/MKL33Z644/startup; ../../../../platform/utilities/inc; ../../../../platform/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL33Z64VLH4; FRDM_KL43Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/hal/adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/hal/dac
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform/hal/dma
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform/hal/dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform/hal/cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/hal/cop
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform/hal/crc
    ../../../../platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../platform/hal/inc/: fsl_crc_hal.h
  group platform/hal/gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/hal/flexio
    ../../../../platform/hal/src/flexio/: fsl_flexio_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_hal.h
  group platform/hal/flexio/uart
    ../../../../platform/hal/src/flexio/: fsl_flexio_uart_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_uart_hal.h
  group platform/hal/flexio/spi
    ../../../../platform/hal/src/flexio/: fsl_flexio_spi_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_spi_hal.h
  group platform/hal/flexio/i2s
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2s_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2s_hal.h
  group platform/hal/flexio/i2c
    ../../../../platform/hal/src/flexio/: fsl_flexio_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_flexio_i2c_hal.h
  group platform/hal/i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/hal/llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform/hal/lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/hal/mcglite
    ../../../../platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcglite_hal.h fsl_mcglite_hal_modes.h
  group platform/hal/osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/hal/pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform/hal/port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/hal/rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform/hal/rtc
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform/hal/sim
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform/hal/sim/system
    ../../../../platform/hal/src/sim/MKL33Z644/: fsl_sim_hal_MKL33Z644.c fsl_sim_hal_MKL33Z644.h
  group platform/hal/slcd
    ../../../../platform/hal/src/slcd/: fsl_slcd_hal.c
    ../../../../platform/hal/inc/: fsl_slcd_hal.h
  group platform/hal/smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/hal/spi
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform/hal/tpm
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform/hal/lpuart
    ../../../../platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../platform/hal/inc/: fsl_lpuart_hal.h
  group platform/hal/uart
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform/hal/pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/hal/vref
    ../../../../platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../platform/hal/inc/: fsl_vref_hal.h
