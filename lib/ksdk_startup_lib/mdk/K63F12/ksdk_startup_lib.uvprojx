# Keil uVision project ksdk_startup_lib.uvprojx, settings and files
target ksdk_startup_lib Debug (ARM-ADS)
  device: MK63FN1M0xxx12 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK63FN1M0VMD12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../platform/devices/MK63F12/startup;../../../../platform/CMSIS/Include;../../../../platform/devices
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group startup
    ../../../../platform/devices/MK63F12/startup/arm/: startup_MK63F12.s
    ../../../../platform/devices/MK63F12/startup/: system_MK63F12.c
    ../../../../platform/devices/: startup.c startup.h
target ksdk_startup_lib Release (ARM-ADS)
  device: MK63FN1M0xxx12 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK63FN1M0VMD12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
