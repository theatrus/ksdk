# Keil uVision project ksdk_startup_lib.uvprojx, settings and files
target ksdk_startup_lib Debug (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: libksdk_startup.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK21DN512AVMC5
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../platform/devices;../../../../platform/devices/MK21DA5/include;../../../../platform/devices/MK21DA5/startup;../../../../platform/CMSIS/Include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../platform/devices/MK21DA5/startup/arm/: startup_MK21DA5.s
    ../../../../platform/devices/MK21DA5/startup/: system_MK21DA5.c
    ../../../../platform/devices/: startup.c startup.h
target ksdk_startup_lib Release (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: as above
  output: libksdk_startup.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK21DN512AVMC5
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
