# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL33Z256xxx4 Freescale MKL33Z256xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL33Z256VLH4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices/MKL33Z4/startup; ../../../../platform/CMSIS/Include; ../../../../platform/devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL33Z256VLH4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKL33Z4/startup/iar/: startup_MKL33Z4.s
    ../../../../platform/devices/MKL33Z4/startup/: system_MKL33Z4.c
    ../../../../platform/devices/: startup.c startup.h
