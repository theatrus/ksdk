# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK52DN512xxx10 Freescale MK52DN512xxx10
  ICCARM.CCDefines: DEBUG; CPU_MK52DN512CMD10
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices/MK52D10/startup; ../../../../platform/CMSIS/Include; ../../../../platform/devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK52DN512CMD10
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MK52D10/startup/iar/: startup_MK52D10.s
    ../../../../platform/devices/MK52D10/startup/: system_MK52D10.c
    ../../../../platform/devices/: startup.c startup.h
