# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 Freescale MKW24D512xxx5
  ICCARM.CCDefines: DEBUG; CPU_MKW24D512VHA5
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKW24D5/include; ../../../../platform/devices/MKW24D5/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW24D512VHA5
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKW24D5/startup/iar/: startup_MKW24D5.s
    ../../../../platform/devices/MKW24D5/startup/: system_MKW24D5.c
    ../../../../platform/devices/: startup.c startup.h
