# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW01Z128xxx4 Freescale MKW01Z128xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKW01Z128CHN4; MRB_KW01
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKW01Z4/include; ../../../../platform/devices/MKW01Z4/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW01Z128CHN4; MRB_KW01
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKW01Z4/startup/iar/: startup_MKW01Z4.s
    ../../../../platform/devices/MKW01Z4/startup/: system_MKW01Z4.c
    ../../../../platform/devices/: startup.c startup.h
