# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV43F128xxx15 Freescale MKV43F128xxx15
  ICCARM.CCDefines: DEBUG; CPU_MKV43F128VLL15
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices/MKV43F15/startup; ../../../../platform/CMSIS/Include; ../../../../platform/devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV43F128VLL15
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKV43F15/startup/iar/: startup_MKV43F15.s
    ../../../../platform/devices/MKV43F15/startup/: system_MKV43F15.c
    ../../../../platform/devices/: startup.c startup.h
