# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK26FN2M0xxx18 Freescale MK26FN2M0xxx18
  ICCARM.CCDefines: DEBUG; CPU_MK26FN2M0VMI18
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MK26F18/include; ../../../../platform/devices/MK26F18/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK26FN2M0VMI18
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MK26F18/startup/iar/: startup_MK26F18.s
    ../../../../platform/devices/MK26F18/startup/: system_MK26F18.c
    ../../../../platform/devices/: startup.c startup.h
