# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL33Z64xxx4 Freescale MKL33Z64xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL33Z64VLH4; FRDM_KL43Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKL33Z644/include; ../../../../platform/devices/MKL33Z644/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL33Z64VLH4; FRDM_KL43Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKL33Z644/startup/iar/: startup_MKL33Z644.s
    ../../../../platform/devices/MKL33Z644/startup/: system_MKL33Z644.c
    ../../../../platform/devices/: startup.c startup.h
