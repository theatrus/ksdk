# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKM34Z256xxx7 Freescale MKM34Z256xxx7
  ICCARM.CCDefines: DEBUG; CPU_MKM34Z256VLQ7
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKM34Z7/include; ../../../../platform/devices/MKM34Z7/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKM34Z256VLQ7
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKM34Z7/startup/iar/: startup_MKM34Z7.s
    ../../../../platform/devices/MKM34Z7/startup/: system_MKM34Z7.c
    ../../../../platform/devices/: startup.c startup.h
