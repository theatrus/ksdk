# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z128xxx7 Freescale MKV10Z128xxx7
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z128VLH7
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKV10Z1287/include; ../../../../platform/devices/MKV10Z1287/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z128VLH7
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKV10Z1287/startup/iar/: startup_MKV10Z1287.s
    ../../../../platform/devices/MKV10Z1287/startup/: system_MKV10Z1287.c
    ../../../../platform/devices/: startup.c startup.h
