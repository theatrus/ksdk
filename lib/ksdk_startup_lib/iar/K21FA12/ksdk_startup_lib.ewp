# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  ICCARM.CCDefines: DEBUG; CPU_MK21FN1M0AVMC12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MK21FA12/include; ../../../../platform/devices/MK21FA12/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK21FN1M0AVMC12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MK21FA12/startup/iar/: startup_MK21FA12.s
    ../../../../platform/devices/MK21FA12/startup/: system_MK21FA12.c
    ../../../../platform/devices/: startup.c startup.h
