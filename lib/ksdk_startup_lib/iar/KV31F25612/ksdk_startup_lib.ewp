# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F256xxx12 Freescale MKV31F256xxx12
  ICCARM.CCDefines: DEBUG; CPU_MKV31F256VLL12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/devices; ../../../../platform/devices/MKV31F25612/include; ../../../../platform/devices/MKV31F25612/startup; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F256VLL12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/devices/MKV31F25612/startup/iar/: startup_MKV31F25612.s
    ../../../../platform/devices/MKV31F25612/startup/: system_MKV31F25612.c
    ../../../../platform/devices/: startup.c startup.h
