# IAR project lwip_httpserver_demo_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_MQX; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/config; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx_stdlib; ../../../../../../tcpip/lwip; ../../../../../../tcpip/lwip/port; ../../../../../../tcpip/lwip/port/arch; ../../../../../../tcpip/lwip/src; ../../../../../../tcpip/lwip/src/include; ../../../../../../tcpip/lwip/src/include/ipv4; ../../../../../../tcpip/lwip/src/include/ipv4/lwip; ../../../../../../tcpip/lwip/src/include/ipv6; ../../../../../../tcpip/lwip/src/include/ipv6/lwip; ../../../../../../tcpip/lwip/src/include/lwip; ../../../../../../tcpip/lwip/src/include/netif; ../../../../../../tcpip/lwip/src/include/posix; ../../../../../../tcpip/lwip/src/include; ../../../../../../platform/utilities/inc; ../../../../../../rtos/mqx/config/mcu/mk64f120m; ../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../boards/common/phyksz8041; ../../../../../../platform/startup/MK64F12; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../../../../boards/common/phyksz8041; ../../../../../../platform/osa/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/startup/MK64F12; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../boards/twrk64f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: lwip_httpserver_demo_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../platform/linker/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/K64F12/debug/libksdk_platform_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_MQX; TWR_K64F120M; TOWER
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/config; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx_stdlib; ../../../../../../tcpip/lwip; ../../../../../../tcpip/lwip/port; ../../../../../../tcpip/lwip/port/arch; ../../../../../../tcpip/lwip/src; ../../../../../../tcpip/lwip/src/include; ../../../../../../tcpip/lwip/src/include/ipv4; ../../../../../../tcpip/lwip/src/include/ipv4/lwip; ../../../../../../tcpip/lwip/src/include/ipv6; ../../../../../../tcpip/lwip/src/include/ipv6/lwip; ../../../../../../tcpip/lwip/src/include/lwip; ../../../../../../tcpip/lwip/src/include/netif; ../../../../../../tcpip/lwip/src/include/posix; ../../../../../../tcpip/lwip/src/include; ../../../../../../platform/utilities/inc; ../../../../../../rtos/mqx/config/mcu/mk64f120m; ../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../boards/common/phyksz8041; ../../../../../../platform/startup/MK64F12; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../../../../boards/common/phyksz8041; ../../../../../../platform/osa/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/startup/MK64F12; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../boards/twrk64f120m
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/K64F12/release/libksdk_platform_mqx.a
  group lwip/port
    ../../../../../../tcpip/lwip/port/arch/: cc.h perf.h
    ../../../../../../tcpip/lwip/port/: ethernetif.c lwipopts.h sys_arch.c lwip_fsl_irq.c
  group lwip/src/api
    ../../../../../../tcpip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../tcpip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../tcpip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/src/core/snmp
    ../../../../../../tcpip/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip/src/include/ipv4
    ../../../../../../tcpip/lwip/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip/src/include/lwip
    ../../../../../../tcpip/lwip/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip/src/include/netif
    ../../../../../../tcpip/lwip/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip/src/include/posix
    ../../../../../../tcpip/lwip/src/include/posix/: netdb.h
    ../../../../../../tcpip/lwip/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../../tcpip/lwip/src/netif/: etharp.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../tcpip/lwip/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/mk64f120m/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/twrk64f120m/: user_config.h
  group Config Files/Common
    ../../../../../../rtos/mqx/config/common/: maximum_config.h small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../../../../boards/common/phyksz8041/: fsl_phy_driver.c
    ../../../src/: httpserver-netconn.c httpserver-netconn.h
  group board
    ../../../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
