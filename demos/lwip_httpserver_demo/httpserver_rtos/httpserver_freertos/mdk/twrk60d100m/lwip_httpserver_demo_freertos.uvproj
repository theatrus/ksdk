# Keil uVision project lwip_httpserver_demo_freertos.uvproj, settings and files
target lwip_httpserver_demo_freertos Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: lwip_httpserver_demo_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, KEIL, FSL_RTOS_FREE_RTOS, TWR_K60D100M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../rtos/FreeRTOS/config/K60D10/mdk;../../../../../../tcpip/lwip;../../../../../../tcpip/lwip/port;../../../../../../tcpip/lwip/port/arch;../../../../../../tcpip/lwip/src;../../../../../../tcpip/lwip/src/include;../../../../../../tcpip/lwip/src/include/ipv4;../../../../../../tcpip/lwip/src/include/ipv4/lwip;../../../../../../tcpip/lwip/src/include/ipv6;../../../../../../tcpip/lwip/src/include/ipv6/lwip;../../../../../../tcpip/lwip/src/include/lwip;../../../../../../tcpip/lwip/src/include/netif;../../../../../../tcpip/lwip/src/include/posix;../../../../../../tcpip/lwip/src/include;../../../../../../platform/utilities/inc;../../../../../../rtos/FreeRTOS/include;../../../../../../rtos/FreeRTOS/src;../../../../../../platform/utilities/inc;../../../../../../boards/common/phyksz8041;../../../../../../platform/osa/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/startup/MK60D10;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../../../../../../boards/twrk60d100m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/K60D10/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../platform/linker/MK60D10/arm/MK60DN512xxx10_flash.scf
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/K60D10/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0xa000"
  group free-rtos
    ../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/startup/MK60D10/arm/: startup_MK60D10.s
    ../../../../../../platform/startup/MK60D10/: system_MK60D10.c
    ../../../../../../platform/startup/: startup.c startup.h
  group lwip-port
    ../../../../../../tcpip/lwip/port/arch/: cc.h perf.h
    ../../../../../../tcpip/lwip/port/: ethernetif.c lwipopts.h sys_arch.c lwip_fsl_irq.c
  group lwip-src-api
    ../../../../../../tcpip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../tcpip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../tcpip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-src-core-snmp
    ../../../../../../tcpip/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip-src-include-ipv4
    ../../../../../../tcpip/lwip/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip-src-include-lwip
    ../../../../../../tcpip/lwip/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip-src-include-netif
    ../../../../../../tcpip/lwip/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip-src-include-posix
    ../../../../../../tcpip/lwip/src/include/posix/: netdb.h
    ../../../../../../tcpip/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../tcpip/lwip/src/netif/: etharp.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../tcpip/lwip/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group source
    ../../../../../../boards/common/phyksz8041/: fsl_phy_driver.c
    ../../../src/: httpserver-netconn.c httpserver-netconn.h
  group board
    ../../../../../../boards/twrk60d100m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target lwip_httpserver_demo_freertos Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: as above
  output: lwip_httpserver_demo_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, KEIL, FSL_RTOS_FREE_RTOS, TWR_K60D100M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/K60D10/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/K60D10/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0xa000"
