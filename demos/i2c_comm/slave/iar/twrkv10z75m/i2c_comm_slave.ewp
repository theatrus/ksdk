# IAR project i2c_comm_slave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z32xxx7 Freescale MKV10Z32xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z32VLF7; IAR; TWR_KV10Z75M; TOWER; TWR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MKV10Z7; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../boards/twrkv10z75m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_comm_slave.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x200
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MKV10Z7/iar/MKV10Z32xxx7_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV10Z7/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z32VLF7; IAR; TWR_KV10Z75M; TOWER; TWR
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV10Z7/release/libksdk_platform.a
  group startup
    ../../../../../platform/startup/MKV10Z7/iar/: startup_MKV10Z7.s
    ../../../../../platform/startup/MKV10Z7/: system_MKV10Z7.c
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../src/: i2c_slave_lowpower_wakeup.c
    ../../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
  group board
    ../../../../../boards/twrkv10z75m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
