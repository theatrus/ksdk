# Keil uVision project bldc_demo.uvproj, settings and files
target bldc_demo Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: bldc_demo.out
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV10Z32VLF7, KEIL, TWR_KV10Z75M, TOWER, CLOCK_SETUP=0, TWR
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/utilities/inc;../../../../platform/osa/inc;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MKV10Z7;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../src/MMCLIB;../../src/MMCLIB/Common;../../src/MMCLIB/GDFLIB;../../src/MMCLIB/GFLIB;../../src/MMCLIB/GMCLIB;../../src/MMCLIB/MLIB;../../src/project/peripherals;../../src/project;../../src/freemaster;../../../../platform/CMSIS/Include/device/MKV10Z7;../../../../platform/hal/src/sim/MKV10Z7
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../platform/linker/MKV10Z7/arm/MKV10Z32xxx7_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/mdk/KV10Z7/debug/libksdk_platform.lib 
../../src/MMCLIB/CM0+_MMCLIB_KEIL.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MKV10Z7/arm/: startup_MKV10Z7.s
    ../../../../platform/startup/MKV10Z7/: system_MKV10Z7.c
    ../../../../platform/startup/: startup.c startup.h
  group source/project
    ../../src/project/: main.c state_machine.c M1_StateMachine.c demonstration.c
  group source/project/peripherals
    ../../src/project/peripherals/: MC33927.c peripherals_init.c
  group source/freemaster
    ../../src/freemaster/: freemaster_appcmd.c freemaster_can.c freemaster_Kxx.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
target bldc_demo Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: as above
  output: bldc_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV10Z32VLF7, KEIL, TWR_KV10Z75M, TOWER, CLOCK_SETUP=0, TWR
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
-O2
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/mdk/KV10Z7/release/libksdk_platform.lib 
../../src/MMCLIB/CM0+_MMCLIB_KEIL.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
