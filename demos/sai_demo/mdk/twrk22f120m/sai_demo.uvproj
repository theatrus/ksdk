# Keil uVision project sai_demo.uvproj, settings and files
target sai_demo Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: sai_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/utilities/inc;../../../../platform/osa/inc;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK22F51212;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../boards/common;../../../../boards/common/sgtl5000;../../../../boards/common/sgtl5000/src;../../../../platform/composite/inc;../../../../platform/drivers/src/edma;../../../../platform/drivers/src/sai;../../../../boards/twrk22f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../platform/linker/MK22F51212/arm/MK22FN512xxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/mdk/K22F51212/debug/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../platform/startup/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
  group soundcard
    ../../../../platform/composite/src/soundcard/: fsl_soundcard.c
    ../../../../platform/composite/inc/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/src/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/src/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target sai_demo Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: sai_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, ARM_MATH_CM4, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/mdk/K22F51212/release/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
