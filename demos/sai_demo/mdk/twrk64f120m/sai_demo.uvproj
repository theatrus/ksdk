# Keil uVision project sai_demo.uvproj, settings and files
target sai_demo Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: sai_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/utilities/inc;../../../../platform/osa/inc;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK64F12;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../boards/common;../../../../boards/common/sgtl5000;../../../../boards/common/sgtl5000/src;../../../../platform/composite/inc;../../../../platform/drivers/src/edma;../../../../platform/drivers/src/sai;../../../../boards/twrk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../platform/linker/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/mdk/K64F12/debug/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
  group soundcard
    ../../../../platform/composite/src/soundcard/: fsl_soundcard.c
    ../../../../platform/composite/inc/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/src/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/src/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target sai_demo Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: sai_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, ARM_MATH_CM4, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/mdk/K64F12/release/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
