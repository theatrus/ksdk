# IAR project sai_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/utilities/inc; ../../../../platform/osa/inc; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/system/inc; ../../../../boards/common; ../../../../boards/common/sgtl5000; ../../../../boards/common/sgtl5000/src; ../../../../platform/composite/inc; ../../../../platform/drivers/src/edma; ../../../../platform/drivers/src/sai; ../../../../boards/twrk64f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sai_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../platform/linker/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; TWR_K64F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/release/libksdk_platform.a
  group startup
    ../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
  group soundcard
    ../../../../platform/composite/src/soundcard/: fsl_soundcard.c
    ../../../../platform/composite/inc/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/src/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/src/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
