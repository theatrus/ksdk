# IAR project adc_lptmr_trigger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VMD10; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K60D100M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK60D10; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../boards/twrk60d100m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: adc_lptmr_trigger.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MK60D10/iar/MK60DN512xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K60D10/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VMD10; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K60D100M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K60D10/release/libksdk_platform.a
  group startup
    ../../../../../platform/startup/MK60D10/iar/: startup_MK60D10.s
    ../../../../../platform/startup/MK60D10/: system_MK60D10.c
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../src/: dac_gen_wave.c adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/twrk60d100m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
