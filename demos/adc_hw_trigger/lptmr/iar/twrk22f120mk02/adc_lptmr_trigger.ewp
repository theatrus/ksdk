# IAR project adc_lptmr_trigger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK02FN128xx10 Freescale MK02FN128xx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK02FN128VLH10; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK02F12810; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../boards/twrk22f120mk02
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: adc_lptmr_trigger.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MK02F12810/iar/MK02FN128xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K02F12810/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK02FN128VLH10; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K02F12810/release/libksdk_platform.a
  group startup
    ../../../../../platform/startup/MK02F12810/iar/: startup_MK02F12810.s
    ../../../../../platform/startup/MK02F12810/: system_MK02F12810.c system_MK02F12810.h
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../src/: dac_gen_wave.c adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/twrk22f120mk02/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
