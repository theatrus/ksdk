# IAR project adc_lptmr_trigger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VDC12; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK22F51212; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../boards/twrk22f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: adc_lptmr_trigger.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MK22F51212/iar/MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K22F51212/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VDC12; IAR; USE_DAC_OUT_AS_SOURCE; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K22F51212/release/libksdk_platform.a
  group startup
    ../../../../../platform/startup/MK22F51212/iar/: startup_MK22F51212.s
    ../../../../../platform/startup/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../src/: dac_gen_wave.c adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
