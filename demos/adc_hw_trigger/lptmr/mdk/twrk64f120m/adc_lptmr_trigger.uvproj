# Keil uVision project adc_lptmr_trigger.uvproj, settings and files
target adc_lptmr_trigger Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: adc_lptmr_trigger.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, USE_DAC_OUT_AS_SOURCE, TWR_K64F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK64F12;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../boards/twrk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../platform/linker/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K64F12/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../src/: dac_gen_wave.c adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target adc_lptmr_trigger Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: adc_lptmr_trigger.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, USE_DAC_OUT_AS_SOURCE, TWR_K64F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K64F12/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
