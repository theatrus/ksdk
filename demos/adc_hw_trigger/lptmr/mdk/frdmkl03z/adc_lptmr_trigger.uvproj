# Keil uVision project adc_lptmr_trigger.uvproj, settings and files
target adc_lptmr_trigger Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: adc_lptmr_trigger.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, KEIL, CLOCK_SETUP=0, FRDM_KL03Z48M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MKL03Z4;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../boards/frdmkl03z
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../../platform/linker/MKL03Z4/arm/MKL03Z32xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL03Z4/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x100"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MKL03Z4/arm/: startup_MKL03Z4.s
    ../../../../../platform/startup/MKL03Z4/: system_MKL03Z4.c
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../src/: adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/frdmkl03z/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target adc_lptmr_trigger Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: adc_lptmr_trigger.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, KEIL, CLOCK_SETUP=0, FRDM_KL03Z48M, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL03Z4/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x100"
