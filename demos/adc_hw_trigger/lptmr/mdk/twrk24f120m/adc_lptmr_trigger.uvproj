# Keil uVision project adc_lptmr_trigger.uvproj, settings and files
target adc_lptmr_trigger Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: adc_lptmr_trigger.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK24FN256VDC12, KEIL, USE_DAC_OUT_AS_SOURCE, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK24F25612;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../boards/twrk24f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../platform/linker/MK24F25612/arm/MK24FN256xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K24F25612/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MK24F25612/arm/: startup_MK24F25612.s
    ../../../../../platform/startup/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../src/: dac_gen_wave.c adc_hw_trigger.c lptmr_trigger.c fsl_adc_irq.c
  group board
    ../../../../../boards/twrk24f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target adc_lptmr_trigger Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: adc_lptmr_trigger.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK24FN256VDC12, KEIL, USE_DAC_OUT_AS_SOURCE, TWR_K24F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K24F25612/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
