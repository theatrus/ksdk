# Keil uVision project mmdvsq_demo.uvproj, settings and files
target mmdvsq_demo Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: mmdvsq_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV10Z32VLF7, KEIL, TWR_KV10Z75M, TOWER, ARM_MATH_CM0PLUS, TWR
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/utilities/inc;../../../../platform/osa/inc;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MKV10Z7;../../../../platform/hal/inc;../../../../platform/drivers/inc;../../../../platform/system/inc;../../../../boards/common;../../../../boards/twrkv10z75m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../platform/linker/MKV10Z7/arm/MKV10Z32xxx7_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/mdk/KV10Z7/debug/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM0l_math.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MKV10Z7/arm/: startup_MKV10Z7.s
    ../../../../platform/startup/MKV10Z7/: system_MKV10Z7.c
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: mmdvsq_demo.c
  group board
    ../../../../boards/twrkv10z75m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target mmdvsq_demo Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: as above
  output: mmdvsq_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV10Z32VLF7, KEIL, TWR_KV10Z75M, TOWER, ARM_MATH_CM0PLUS, TWR
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
-O0
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/mdk/KV10Z7/release/libksdk_platform.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM0l_math.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200" 
--predefine="-D__ram_vector_table__=1"
