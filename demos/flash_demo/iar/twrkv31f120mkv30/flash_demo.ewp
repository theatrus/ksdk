# IAR project flash_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV30F128xxx10 Freescale MKV30F128xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CLOCK_SETUP=0; CPU_MKV30F128VLH10; IAR; TWR_KV30F100M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/utilities/inc; ../../../../platform/osa/inc; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MKV30F12810; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/system/inc; ../../../../platform/drivers/src/flash/C90TFS/drvsrc/include; ../../src; ../../../../boards/twrkv31f120mkv30
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flash_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400
  ILINK.IlinkIcfFile: ../../../../platform/linker/MKV30F12810/iar/MKV30F128xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/KV30F12810/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCK_SETUP=0; CPU_MKV30F128VLH10; IAR; TWR_KV30F100M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/KV30F12810/release/libksdk_platform.a
  group startup
    ../../../../platform/startup/MKV30F12810/iar/: startup_MKV30F12810.s
    ../../../../platform/startup/MKV30F12810/: system_MKV30F12810.c system_MKV30F12810.h
    ../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../src/: flash_demo.c flash_swap.c
  group flash
    ../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../../../../boards/twrkv31f120mkv30/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
