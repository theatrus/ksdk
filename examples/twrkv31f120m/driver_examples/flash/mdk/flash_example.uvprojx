# Keil uVision project flash_example.uvprojx, settings and files
target flash_example Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: flash_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV31F512VLL12, CLOCK_INIT_CONFIG=CLOCK_RUN, TWR_KV31F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKV31F51212/include;../../../../../platform/devices/MKV31F51212/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/utilities/inc;../../..;../../../../../platform/drivers/src/flash;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../platform/devices/MKV31F51212/linker/arm/MKV31F512xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV31F51212/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKV31F51212/startup/arm/: startup_MKV31F51212.s
    ../../../../../platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashVerifySection.c
target flash_example Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: as above
  output: flash_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV31F512VLL12, CLOCK_INIT_CONFIG=CLOCK_RUN, TWR_KV31F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV31F51212/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
