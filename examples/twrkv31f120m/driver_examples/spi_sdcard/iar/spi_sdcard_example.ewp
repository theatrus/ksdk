# IAR project spi_sdcard_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER; PRINTF_FLOAT_ENABLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MKV31F51212/include; ../../../../../platform/devices/MKV31F51212/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../platform/utilities/inc; ../../..; ../../../../../platform/drivers/src; ../../../../../platform/composite/src/sdcard; ../../../../../platform/composite/inc; ../../../../../platform/drivers/src/dspi; ../../../../../platform/drivers/src/edma
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: spi_sdcard_example.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MKV31F51212/linker/iar/MKV31F512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV31F51212/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER; PRINTF_FLOAT_ENABLE
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV31F51212/release/libksdk_platform.a
  group startup
    ../../../../../platform/devices/MKV31F51212/startup/iar/: startup_MKV31F51212.s
    ../../../../../platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../../../../../platform/drivers/src/dspi/: fsl_dspi_irq.c
    ../: main.c fsl_gpio_irq.c
    ../../../../../platform/composite/src/sdcard/: fsl_sdcard_spi.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
