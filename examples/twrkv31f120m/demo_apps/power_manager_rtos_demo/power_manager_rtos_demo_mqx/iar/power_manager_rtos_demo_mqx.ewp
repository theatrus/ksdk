# IAR project power_manager_rtos_demo_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER; FSL_RTOS_MQX
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug/config; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug/mqx; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug/mqx_stdlib; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKV31F51212/include; ../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/mqx/config/mcu/MKV31F51212; ../../../../../../rtos/mqx/config/board/twrkv31f120m; ../..; ../../../../../../platform/devices/MKV31F51212/include; ../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager_rtos_demo_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKV31F51212/linker/iar/MKV31F512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/KV31F51212/debug/libksdk_platform_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; TWR_KV31F120M; TOWER; FSL_RTOS_MQX
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release/config; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release/mqx; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release/mqx_stdlib; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKV31F51212/include; ../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/mqx/config/mcu/MKV31F51212; ../../../../../../rtos/mqx/config/board/twrkv31f120m; ../..; ../../../../../../platform/devices/MKV31F51212/include; ../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/twrkv31f120m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/KV31F51212/release/libksdk_platform_mqx.a
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MKV31F51212/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/twrkv31f120m/: user_config.h
  group Config Files/Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h debug_console_lpm_callback.c fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c fsl_uart_irq.c main.c lpm_rtos.h lptmr_setup.c lptmr_setup.h register_callback.c rtc_setup.c rtc_setup.h rtos_lpm_callback.c task_led_toggle.c task_lpm.c task_lpm.h
