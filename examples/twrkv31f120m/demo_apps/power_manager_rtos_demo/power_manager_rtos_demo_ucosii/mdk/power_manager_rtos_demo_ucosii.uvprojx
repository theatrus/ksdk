# Keil uVision project power_manager_rtos_demo_ucosii.uvprojx, settings and files
target power_manager_rtos_demo_ucosii Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV31F512VLL12, FSL_RTOS_UCOSII, TWR_KV31F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../rtos/uCOSII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKV31F51212/include;../../../../../../platform/devices/MKV31F51212/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/uCOSII/src/config;../../../../../../rtos/uCOSII/src/uCOS-II/Source;../../../../../../rtos/uCOSII/src/uC-CPU;../../../../../../rtos/uCOSII/src/uC-LIB;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../platform/devices/MKV31F51212/linker/arm/MKV31F512xxx12_flash.scf
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/KV31F51212/debug/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group ucosii
    ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c os_dbg.c
    ../../../../../../rtos/uCOSII/src/config/: app_hooks.c
    ../../../../../../rtos/uCOSII/src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group startup
    ../../../../../../platform/devices/MKV31F51212/startup/arm/: startup_MKV31F51212.s
    ../../../../../../platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.h
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target power_manager_rtos_demo_ucosii Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: as above
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV31F512VLL12, FSL_RTOS_UCOSII, TWR_KV31F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/KV31F51212/release/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
