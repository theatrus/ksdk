# Keil uVision project dev_phdc_weighscale_ucosii.uvprojx, settings and files
target dev_phdc_weighscale_ucosii Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: dev_phdc_weighscale_ucosii.out +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1, CPU_MKW24D512VHA5, CLOCK_SETUP=4, FSL_RTOS_UCOSII, USB_KW24D512, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../../../rtos/uCOSII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../../../platform/osa/inc;../../../../../../../../../rtos;../../../../../../../../../platform/utilities/inc;../../../../../../../../../platform/CMSIS/Include;../../../../../../../../../platform/devices;../../../../../../../../../platform/devices/MKW24D5/include;../../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../twrkw24d512;../../../../../../../../../usb/adapter/sources;../../../../../../../../../usb/adapter/sources/sdk;../../../../../../../../../usb/usb_core/device/include/MKW24D5;../../../../../../../../../usb/usb_core/device/include;../../../../../../../../../usb/usb_core/device/sources/classes/audio;../../../../../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../../../../../usb/usb_core/device/sources/classes/common;../../../../../../../../../usb/usb_core/device/sources/classes/composite;../../../../../../../../../usb/usb_core/device/sources/classes/hid;../../../../../../../../../usb/usb_core/device/sources/classes/include;../../../../../../../../../usb/usb_core/device/sources/classes/include/config;../../../../../../../../../usb/usb_core/device/sources/classes/msd;../../../../../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../../../../../usb/usb_core/device/sources/classes/video;../../../../../../../../../usb/usb_core/device/sources/controller/khci;../../../../../../../../../usb/usb_core/device/sources/controller;../../../../../../../../../usb/usb_core/hal;../../../../../../../../../usb/usb_core/host/include;../../../../../../../../../usb/usb_core/host/sources/classes/audio;../../../../../../../../../usb/usb_core/host/sources/classes/cdc;../../../../../../../../../usb/usb_core/host/sources/classes/hid;../../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../../usb/usb_core/host/sources/classes/phdc;../../../../../../../../../usb/usb_core/host/sources/classes/printer;../../../../../../../../../usb/usb_core/host/sources/controller/khci;../../../../../../../../../usb/usb_core/host/sources/controller;../../../../../../../../../usb/usb_core/include;../../../../../../../../../usb/usb_core/otg/sources/driver/khci;../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk;../../../../../../../../../usb/usb_core/otg/include;../../../../../../../../../usb/usb_core/otg/sources/otg;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/uart;../../../../../../../../../platform/drivers/src/gpio;../../../../../../../../../platform/drivers/src/pit;../../../../../../../../../platform/drivers/src/edma;../../../../../../../../../platform/system/inc;../../../../../../../../../rtos/uCOSII/src/config;../../../../../../../../../rtos/uCOSII/src/uCOS-II/Source;../../../../../../../../../rtos/uCOSII/src/uC-CPU;../../../../../../../../../rtos/uCOSII/src/uC-LIB;../../../../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../../../platform/devices/MKW24D5/linker/arm/MKW24D512xxx5_flash.scf
  link misc: ../../../../../../../../../usb/usb_core/device/lib/ucosii/mdk/MKW24D5/debug/libusbd_ucosii.lib 
../../../../../../../../../lib/ksdk_ucosii_lib/mdk/KW24D5/debug/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
  group ucosii
    ../../../../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c os_dbg.c
    ../../../../../../../../../rtos/uCOSII/src/config/: app_hooks.c
    ../../../../../../../../../rtos/uCOSII/src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../../platform/devices/MKW24D5/startup/arm/: startup_MKW24D5.s
    ../../../../../../../../../platform/devices/MKW24D5/startup/: system_MKW24D5.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: ieee11073_nom_codes.h ieee11073_phd_types.h phd_com_model.c phd_com_model.h usb_descriptor.c usb_descriptor.h weighscale.c weighscale.h
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
target dev_phdc_weighscale_ucosii Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: as above
  output: dev_phdc_weighscale_ucosii.out +hex
  c flags: Optim=4 OneElfS=1
  c define: _DEBUG=0, CPU_MKW24D512VHA5, CLOCK_SETUP=4, FSL_RTOS_UCOSII, USB_KW24D512, DONGLE
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../../../../usb/usb_core/device/lib/ucosii/mdk/MKW24D5/release/libusbd_ucosii.lib 
../../../../../../../../../lib/ksdk_ucosii_lib/mdk/KW24D5/release/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
