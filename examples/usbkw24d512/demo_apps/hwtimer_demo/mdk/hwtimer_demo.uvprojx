# Keil uVision project hwtimer_demo.uvprojx, settings and files
target hwtimer_demo Debug (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: hwtimer_demo.out +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG, CPU_MKW24D512VHA5, USB_KW24D512, BOARD_USE_VIRTUALCOM, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/utilities/inc/virtual_com;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKW24D5/include;../../../../../platform/devices/MKW24D5/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../usb/adapter/sources;../../../../../usb/adapter/sources/sdk;../../../../../usb/usb_core/hal;../../../../../usb/usb_core/include;../../../../../usb/usb_core/device/include/usbkw24d512;../../../../../usb/usb_core/device/include;../../../../../usb/usb_core/device/sources/classes/audio;../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../usb/usb_core/device/sources/classes/common;../../../../../usb/usb_core/device/sources/classes/composite;../../../../../usb/usb_core/device/sources/classes/hid;../../../../../usb/usb_core/device/sources/classes/include;../../../../../usb/usb_core/device/sources/classes/msd;../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../usb/usb_core/device/sources/controller/khci;../../../../../usb/usb_core/device/sources/controller;../../../../../platform/utilities/inc;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../platform/devices/MKW24D5/linker/arm/MKW24D512xxx5_flash.scf
  link misc: ../../../../../usb/usb_core/device/build/mdk/usbd_sdk_usbkw24d512_bm/debug/libusbd_bm.lib 
../../../../../lib/ksdk_platform_lib/mdk/KW24D5/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/src/virtual_com/: usb_descriptor.c virtual_com.c
    ../../../../../platform/utilities/inc/virtual_com/: usb_descriptor.h virtual_com.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKW24D5/startup/arm/: startup_MKW24D5.s
    ../../../../../platform/devices/MKW24D5/startup/: system_MKW24D5.c
    ../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c
    ../../../../../platform/system/src/hwtimer/: fsl_hwtimer_systick_irq.c fsl_hwtimer_pit_irq.c
target hwtimer_demo Release (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  cpu: as above
  output: hwtimer_demo.out +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKW24D512VHA5, USB_KW24D512, BOARD_USE_VIRTUALCOM, DONGLE
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../usb/usb_core/device/build/mdk/usbd_sdk_usbkw24d512_bm/release/libusbd_bm.lib 
../../../../../lib/ksdk_platform_lib/mdk/KW24D5/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
