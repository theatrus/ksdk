<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>mqx_frdmk22f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk22f</project><configuration>debug</configuration></member><member><project>usbh_sdk_frdmk22f_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>host_hid_mouse_frdmk22f_mqx</project><configuration>Debug</configuration></member><member><project>mqx_frdmk22f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk22f</project><configuration>release</configuration></member><member><project>usbh_sdk_frdmk22f_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>host_hid_mouse_frdmk22f_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>mqx_frdmk22f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk22f</project><configuration>debug</configuration></member><member><project>usbh_sdk_frdmk22f_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>host_hid_mouse_frdmk22f_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>mqx_frdmk22f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk22f</project><configuration>release</configuration></member><member><project>usbh_sdk_frdmk22f_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>host_hid_mouse_frdmk22f_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx/build/iar/mqx_frdmk22f/mqx_frdmk22f.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_frdmk22f/mqx_stdlib_frdmk22f.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/build/iar/usbh_sdk_frdmk22f_mqx/usbh_sdk_frdmk22f_mqx.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_mqx_lib/iar/K22F51212/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/host_hid_mouse_frdmk22f_mqx.ewp</path></project></workspace>
