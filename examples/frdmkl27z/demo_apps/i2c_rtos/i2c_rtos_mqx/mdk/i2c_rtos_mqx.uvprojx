# Keil uVision project i2c_rtos_mqx.uvprojx, settings and files
target i2c_rtos_mqx Release (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: i2c_rtos_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL27Z64VLH4, FSL_RTOS_MQX, FRDM_KL27Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-J../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/config  -J../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx  -J../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx_stdlib  -J#J
  c include: ../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release;../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/config;../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx;../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx_stdlib;../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/nshell;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKL27Z644/include;../../../../../../platform/devices/MKL27Z644/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../../platform/drivers/src/uart;../../../../../../platform/drivers/src/i2c;../../../../../../rtos/mqx/config/mcu/MKL27Z644;../../../../../../rtos/mqx/config/board/frdmkl27z;../..;../../../../../../platform/devices/MKL27Z644/include;../../../../../../platform/devices/MKL27Z644/startup;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/startup;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/mqx/source/include;../../../..
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../../platform/devices/MKL27Z644/linker/arm/MKL27Z64xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_mqx_lib/mdk/KL27Z644/release/libksdk_platform_mqx.lib 
../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/nshell/lib_nshell.lib 
../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx/lib_mqx.lib 
../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../rtos/mqx/lib/frdmkl27z.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x300" 
--predefine="-D__heap_size__=0x200" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../: i2c_mqx_rtos_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MKL27Z644/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/frdmkl27z/: user_config.h
