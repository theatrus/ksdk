# IAR project i2c_rtos_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 Freescale MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_MQX; FRDM_KL27Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug/config; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug/mqx; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug/mqx_stdlib; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL27Z644/include; ../../../../../../platform/devices/MKL27Z644/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/mqx/config/mcu/MKL27Z644; ../../../../../../rtos/mqx/config/board/frdmkl27z; ../../../../../../platform/devices/MKL27Z644/include; ../../../../../../platform/devices/MKL27Z644/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x300; __heap_size__=0x200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKL27Z644/linker/iar/MKL27Z64xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/KL27Z644/debug/libksdk_platform_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_MQX; FRDM_KL27Z; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release/config; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release/mqx; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release/mqx_stdlib; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL27Z644/include; ../../../../../../platform/devices/MKL27Z644/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/mqx/config/mcu/MKL27Z644; ../../../../../../rtos/mqx/config/board/frdmkl27z; ../../../../../../platform/devices/MKL27Z644/include; ../../../../../../platform/devices/MKL27Z644/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release/mqx/lib_mqx.a; ../../../../../../rtos/mqx/lib/frdmkl27z.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../lib/ksdk_mqx_lib/iar/KL27Z644/release/libksdk_platform_mqx.a
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MKL27Z644/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/frdmkl27z/: user_config.h
  group Config Files/Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: i2c_mqx_rtos_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
