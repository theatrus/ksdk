# IAR project i2c_rtos_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 Freescale MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_UCOSIII; FRDM_KL27Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR; ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/IAR; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL27Z644/include; ../../../../../../platform/devices/MKL27Z644/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/uCOSIII/src/config; ../../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_ucosiii.out
  ILINK.IlinkConfigDefines: __stack_size__=0x300; __heap_size__=0x200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKL27Z644/linker/iar/MKL27Z64xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosiii_lib/iar/KL27Z644/debug/libksdk_platform_ucosiii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_UCOSIII; FRDM_KL27Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosiii_lib/iar/KL27Z644/release/libksdk_platform_ucosiii.a
  group ucosiii
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/IAR/: cpu_c.c cpu_a.asm
    ../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group startup
    ../../../../../../platform/devices/MKL27Z644/startup/iar/: startup_MKL27Z644.s
    ../../../../../../platform/devices/MKL27Z644/startup/: system_MKL27Z644.c
    ../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: fsl_i2c_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
