# Keil uVision project power_manager_rtos_demo_bm.uvprojx, settings and files
target power_manager_rtos_demo_bm Debug (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: power_manager_rtos_demo_bm.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL27Z64VLH4, FSL_RTOS_BM, FRDM_KL27Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKL27Z644/include;../../../../../../platform/devices/MKL27Z644/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../../platform/devices/MKL27Z644/linker/arm/MKL27Z64xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/KL27Z644/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x300" 
--predefine="-D__heap_size__=0x200" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MKL27Z644/startup/arm/: startup_MKL27Z644.s
    ../../../../../../platform/devices/MKL27Z644/startup/: system_MKL27Z644.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_lptmr_irq.c fsl_rtc_irq.c fsl_adc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target power_manager_rtos_demo_bm Release (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: as above
  output: power_manager_rtos_demo_bm.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL27Z64VLH4, FSL_RTOS_BM, FRDM_KL27Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/KL27Z644/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x300" 
--predefine="-D__heap_size__=0x200" 
--predefine="-D__ram_vector_table__=1"
