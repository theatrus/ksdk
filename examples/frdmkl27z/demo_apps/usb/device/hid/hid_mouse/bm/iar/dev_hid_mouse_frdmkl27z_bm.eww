<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbd_sdk_frdmkl27z_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_mouse_frdmkl27z_bm</project><configuration>Debug</configuration></member><member><project>usbd_sdk_frdmkl27z_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>dev_hid_mouse_frdmkl27z_bm</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbd_sdk_frdmkl27z_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_mouse_frdmkl27z_bm</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbd_sdk_frdmkl27z_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>dev_hid_mouse_frdmkl27z_bm</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/device/build/iar/usbd_sdk_frdmkl27z_bm/usbd_sdk_frdmkl27z_bm.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_platform_lib/iar/KL27Z644/ksdk_platform_lib.ewp</path></project><project><path>$WS_DIR$/dev_hid_mouse_frdmkl27z_bm.ewp</path></project></workspace>
