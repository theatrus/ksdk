# Keil uVision project flash_demo.uvprojx, settings and files
target flash_demo Debug (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: flash_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKL27Z644/include;../../../../../platform/devices/MKL27Z644/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/utilities/inc;../../..;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../platform/devices/MKL27Z644/linker/arm/MKL27Z64xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL27Z644/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKL27Z644/startup/arm/: startup_MKL27Z644.s
    ../../../../../platform/devices/MKL27Z644/startup/: system_MKL27Z644.c
    ../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c flash_swap.c
  group flash
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
target flash_demo Release (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: as above
  output: flash_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL27Z64VLH4, FRDM_KL27Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL27Z644/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
