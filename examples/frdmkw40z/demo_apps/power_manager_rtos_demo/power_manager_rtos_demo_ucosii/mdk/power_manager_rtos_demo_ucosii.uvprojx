# Keil uVision project power_manager_rtos_demo_ucosii.uvprojx, settings and files
target power_manager_rtos_demo_ucosii Debug (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.1.0
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_UCOSII, FRDM_KW40Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M0/Generic/RealView;../../../../../../rtos/uCOSII/src/uC-CPU/ARM-Cortex-M0/RealView;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKW40Z4/include;../../../../../../platform/devices/MKW40Z4/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/uCOSII/src/config;../../../../../../rtos/uCOSII/src/uCOS-II/Source;../../../../../../rtos/uCOSII/src/uC-CPU;../../../../../../rtos/uCOSII/src/uC-LIB;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../../platform/devices/MKW40Z4/linker/arm/MKW40Z160xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/KW40Z4/debug/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x1500" 
--predefine="-D__heap_size__=0x1500" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group ucosii
    ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c os_dbg.c
    ../../../../../../rtos/uCOSII/src/config/: app_hooks.c
    ../../../../../../rtos/uCOSII/src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group startup
    ../../../../../../platform/devices/MKW40Z4/startup/arm/: startup_MKW40Z4.s
    ../../../../../../platform/devices/MKW40Z4/startup/: system_MKW40Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target power_manager_rtos_demo_ucosii Release (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.1.0
  cpu: as above
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_UCOSII, FRDM_KW40Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/KW40Z4/release/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x1500" 
--predefine="-D__heap_size__=0x1500" 
--predefine="-D__ram_vector_table__=1"
