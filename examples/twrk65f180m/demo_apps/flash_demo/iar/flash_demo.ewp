# IAR project flash_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK65F18/include; ../../../../../platform/devices/MK65F18/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../platform/utilities/inc; ../../..; ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flash_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK65F18/linker/iar/MK65FN2M0xxx18_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K65F18/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K65F18/release/libksdk_platform.a
  group startup
    ../../../../../platform/devices/MK65F18/startup/iar/: startup_MK65F18.s
    ../../../../../platform/devices/MK65F18/startup/: system_MK65F18.c
    ../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c flash_swap.c
  group flash
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
