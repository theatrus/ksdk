# Keil uVision project power_manager_rtos_demo_ucosii.uvprojx, settings and files
target power_manager_rtos_demo_ucosii Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK65FN2M0VMI18, TWR_K65F180M, TOWER, FSL_RTOS_UCOSII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../rtos/uCOSII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MK65F18/include;../../../../../../platform/devices/MK65F18/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../../../../../../rtos/uCOSII/src/config;../../../../../../rtos/uCOSII/src/uCOS-II/Source;../../../../../../rtos/uCOSII/src/uC-CPU;../../../../../../rtos/uCOSII/src/uC-LIB;../../../../../../platform/utilities/inc;../../../..;../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../platform/devices/MK65F18/linker/arm/MK65FN2M0xxx18_flash.scf
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/K65F18/debug/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group ucosii
    ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c os_dbg.c
    ../../../../../../rtos/uCOSII/src/config/: app_hooks.c
    ../../../../../../rtos/uCOSII/src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MK65F18/startup/arm/: startup_MK65F18.s
    ../../../../../../platform/devices/MK65F18/startup/: system_MK65F18.c
    ../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h debug_console_lpm_callback.c fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c fsl_uart_irq.c main.c lpm_rtos.h lptmr_setup.c lptmr_setup.h register_callback.c rtc_setup.c rtc_setup.h rtos_lpm_callback.c task_led_toggle.c task_lpm.c task_lpm.h
target power_manager_rtos_demo_ucosii Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  cpu: as above
  output: power_manager_rtos_demo_ucosii.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK65FN2M0VMI18, TWR_K65F180M, TOWER, FSL_RTOS_UCOSII
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_ucosii_lib/mdk/K65F18/release/libksdk_platform_ucosii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
