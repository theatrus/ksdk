# Keil uVision project host_msd_fatfs_freertos.uvprojx, settings and files
target host_msd_fatfs_freertos Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: host_msd_fatfs_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK65FN2M0VMI18, USB_DISK_ENABLE=1, FSL_RTOS_FREE_RTOS, TWR_K65F180M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../../../rtos/FreeRTOS/config/K65F18/mdk;../../../../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../../../../platform/osa/inc;../../../../../../../../../rtos;../../../../../../../../../platform/utilities/inc;../../../../../../../../../platform/CMSIS/Include;../../../../../../../../../platform/devices;../../../../../../../../../platform/devices/MK65F18/include;../../../../../../../../../platform/devices/MK65F18/startup;../../../../../../..;../../../../../../../../../usb/adapter/sources;../../../../../../../../../usb/adapter/sources/sdk;../../../../../../../../../usb/usb_core/device/include/MK65F18;../../../../../../../../../usb/usb_core/device/include;../../../../../../../../../usb/usb_core/device/sources/classes/audio;../../../../../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../../../../../usb/usb_core/device/sources/classes/common;../../../../../../../../../usb/usb_core/device/sources/classes/composite;../../../../../../../../../usb/usb_core/device/sources/classes/hid;../../../../../../../../../usb/usb_core/device/sources/classes/include;../../../../../../../../../usb/usb_core/device/sources/classes/include/config;../../../../../../../../../usb/usb_core/device/sources/classes/msd;../../../../../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../../../../../usb/usb_core/device/sources/classes/video;../../../../../../../../../usb/usb_core/device/sources/controller/khci;../../../../../../../../../usb/usb_core/device/sources/controller/ehci;../../../../../../../../../usb/usb_core/device/sources/controller;../../../../../../../../../usb/usb_core/hal;../../../../../../../../../usb/usb_core/host/include/MK65F18;../../../../../../../../../usb/usb_core/host/include;../../../../../../../../../usb/usb_core/host/sources/classes/audio;../../../../../../../../../usb/usb_core/host/sources/classes/cdc;../../../../../../../../../usb/usb_core/host/sources/classes/hid;../../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../../usb/usb_core/host/sources/classes/phdc;../../../../../../../../../usb/usb_core/host/sources/classes/printer;../../../../../../../../../usb/usb_core/host/sources/controller/khci;../../../../../../../../../usb/usb_core/host/sources/controller/ehci;../../../../../../../../../usb/usb_core/host/sources/controller;../../../../../../../../../usb/usb_core/include;../../../../../../../../../usb/usb_core/otg/sources/driver/khci;../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk;../../../../../../../../../usb/usb_core/otg/include;../../../../../../../../../usb/usb_core/otg/sources/otg;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/uart;../../../../../../../../../platform/drivers/src/gpio;../../../../../../../../../platform/drivers/src/pit;../../../../../../../../../platform/drivers/src/edma;../../../../../../../../../platform/system/inc;../..;../../../../../../../../../platform/hal;../../../../../../../../../platform/drivers/src/i2c;../../../../../../../../../middleware/filesystem/fatfs;../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk;../../../../../../../../../rtos/FreeRTOS/include;../../../../../../../../../rtos/FreeRTOS/src
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../../rtos/FreeRTOS/config/K65F18/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../../platform/devices/MK65F18/linker/arm/MK65FN2M0xxx18_flash.scf
  link misc: ../../../../../../../../../usb/usb_core/host/lib/freertos/mdk/MK65F18/debug/libusbh_freertos.lib 
../../../../../../../../../lib/ksdk_freertos_lib/mdk/K65F18/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
  group free-rtos
    ../../../../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../../platform/devices/MK65F18/startup/arm/: startup_MK65F18.s
    ../../../../../../../../../platform/devices/MK65F18/startup/: system_MK65F18.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: main.c msd_fat_demo.c
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources:fatfs
    ../../../../../../../../../middleware/filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources:fatfs:option
    ../../../../../../../../../middleware/filesystem/fatfs/option/: unicode.c
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
target host_msd_fatfs_freertos Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  cpu: as above
  output: host_msd_fatfs_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MK65FN2M0VMI18, USB_DISK_ENABLE=1, FSL_RTOS_FREE_RTOS, TWR_K65F180M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../../rtos/FreeRTOS/config/K65F18/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../../../../usb/usb_core/host/lib/freertos/mdk/MK65F18/release/libusbh_freertos.lib 
../../../../../../../../../lib/ksdk_freertos_lib/mdk/K65F18/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
