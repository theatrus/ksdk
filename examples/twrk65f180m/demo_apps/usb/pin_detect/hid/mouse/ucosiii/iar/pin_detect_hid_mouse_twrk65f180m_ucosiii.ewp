# IAR project pin_detect_hid_mouse_twrk65f180m_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER; FSL_RTOS_UCOSIII
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK65F18/include; ../../../../../../../../../platform/devices/MK65F18/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/twrk65f180m; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller/ehci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/twrk65f180m; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller/ehci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/sources/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/system/inc; ../../../../../../../../../rtos/uCOSIII/src/config; ../../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../../../../../rtos/uCOSIII/src/uC-LIB; ../..; ../../../../../../../../../platform/drivers/src/sai; ../../../../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: pin_detect_hid_mouse_ucosiii.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MK65F18/linker/iar/MK65FN2M0xxx18_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/build/iar/usbh_sdk_twrk65f180m_ucosiii/debug/libusbh_ucosiii.a; ../../../../../../../../../usb/usb_core/device/build/iar/usbd_sdk_twrk65f180m_ucosiii/debug/libusbd_ucosiii.a; ../../../../../../../../../lib/ksdk_ucosiii_lib/iar/K65F18/debug/libksdk_platform_ucosiii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK65FN2M0VMI18; TWR_K65F180M; TOWER; FSL_RTOS_UCOSIII
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/build/iar/usbh_sdk_twrk65f180m_ucosiii/release/libusbh_ucosiii.a; ../../../../../../../../../usb/usb_core/device/build/iar/usbd_sdk_twrk65f180m_ucosiii/release/libusbd_ucosiii.a; ../../../../../../../../../lib/ksdk_ucosiii_lib/iar/K65F18/release/libksdk_platform_ucosiii.a
  group ucosiii
    ../../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
    ../../../../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group startup
    ../../../../../../../../../platform/devices/MK65F18/startup/iar/: startup_MK65F18.s
    ../../../../../../../../../platform/devices/MK65F18/startup/: system_MK65F18.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
    ../../: hardware_init.c
  group sources
    ../../: dev_mouse.c dev_mouse.h dev_mouse_api.h host_mouse.c host_mouse.h host_mouse_api.h pin_detect_mouse.c pin_detect_mouse.h usb_descriptor.c usb_descriptor.h
