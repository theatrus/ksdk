# IAR project lwip_httpserver_demo_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_MQX; TWR_K65F180M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/mqx_stdlib; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/nshell; ../..; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/devices; ../../../../../../../../platform/devices/MK65F18/include; ../../../../../../../../platform/devices/MK65F18/startup; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/system/inc; ../../../../../../../../middleware/tcpip/lwip; ../../../../../../../../middleware/tcpip/lwip/port; ../../../../../../../../middleware/tcpip/lwip/port/arch; ../../../../../../../../middleware/tcpip/lwip/src; ../../../../../../../../middleware/tcpip/lwip/src/include; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv6; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv6/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/netif; ../../../../../../../../middleware/tcpip/lwip/src/include/posix; ../../../../../../../../middleware/tcpip/lwip/src/include; ../../../../../../../../platform/utilities/inc; ../../../../../../../../rtos/mqx/config/mcu/MK65F18; ../../../../../../../../rtos/mqx/config/board/twrk65f180m; ../..; ../../../../../../../../platform/devices/MK65F18/include; ../../../../../../../../platform/devices/MK65F18/startup; ../../../../../../../../platform/system/inc; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/startup; ../../../../../../../../rtos/mqx/config/common; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: lwip_httpserver_demo_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MK65F18/linker/iar/MK65FN2M0xxx18_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K65F18/debug/libksdk_platform_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/debug/mqx/lib_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; FSL_RTOS_MQX; TWR_K65F180M; TOWER
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/mqx_stdlib; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/nshell; ../..; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/devices; ../../../../../../../../platform/devices/MK65F18/include; ../../../../../../../../platform/devices/MK65F18/startup; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/system/inc; ../../../../../../../../middleware/tcpip/lwip; ../../../../../../../../middleware/tcpip/lwip/port; ../../../../../../../../middleware/tcpip/lwip/port/arch; ../../../../../../../../middleware/tcpip/lwip/src; ../../../../../../../../middleware/tcpip/lwip/src/include; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv6; ../../../../../../../../middleware/tcpip/lwip/src/include/ipv6/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/lwip; ../../../../../../../../middleware/tcpip/lwip/src/include/netif; ../../../../../../../../middleware/tcpip/lwip/src/include/posix; ../../../../../../../../middleware/tcpip/lwip/src/include; ../../../../../../../../platform/utilities/inc; ../../../../../../../../rtos/mqx/config/mcu/MK65F18; ../../../../../../../../rtos/mqx/config/board/twrk65f180m; ../..; ../../../../../../../../platform/devices/MK65F18/include; ../../../../../../../../platform/devices/MK65F18/startup; ../../../../../../../../platform/system/inc; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/startup; ../../../../../../../../rtos/mqx/config/common; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../..
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K65F18/release/libksdk_platform_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../../rtos/mqx/lib/twrk65f180m.iar/release/mqx/lib_mqx.a
  group source
    ../../: fsl_phy_driver.c main.c httpserver-netconn.h
  group board
    ../../: hardware_init.c
    ../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group lwip/port
    ../../../../../../../../middleware/tcpip/lwip/port/arch/: cc.h perf.h
    ../../../../../../../../middleware/tcpip/lwip/port/: ethernetif.c lwipopts.h sys_arch.c lwip_fsl_irq.c
    ../../../../../../../../platform/system/src/hwtimer/: fsl_hwtimer_pit_irq.c
  group lwip/src/api
    ../../../../../../../../middleware/tcpip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../../../middleware/tcpip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../../../middleware/tcpip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/src/core/snmp
    ../../../../../../../../middleware/tcpip/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip/src/include/ipv4
    ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip/src/include/lwip
    ../../../../../../../../middleware/tcpip/lwip/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip/src/include/netif
    ../../../../../../../../middleware/tcpip/lwip/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip/src/include/posix
    ../../../../../../../../middleware/tcpip/lwip/src/include/posix/: netdb.h
    ../../../../../../../../middleware/tcpip/lwip/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../../../../middleware/tcpip/lwip/src/netif/: etharp.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../../../middleware/tcpip/lwip/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MK65F18/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk65f180m/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
