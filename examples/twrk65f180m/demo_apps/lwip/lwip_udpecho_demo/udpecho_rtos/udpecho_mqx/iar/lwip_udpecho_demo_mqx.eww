<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>mqx_twrk65f180m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>lwip_udpecho_demo_mqx</project><configuration>Debug</configuration></member><member><project>mqx_twrk65f180m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>lwip_udpecho_demo_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>mqx_twrk65f180m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>lwip_udpecho_demo_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>mqx_twrk65f180m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>lwip_udpecho_demo_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../rtos/mqx/mqx/build/iar/mqx_twrk65f180m/mqx_twrk65f180m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_twrk65f180m/mqx_stdlib_twrk65f180m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../lib/ksdk_mqx_lib/iar/K65F18/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/lwip_udpecho_demo_mqx.ewp</path></project></workspace>
