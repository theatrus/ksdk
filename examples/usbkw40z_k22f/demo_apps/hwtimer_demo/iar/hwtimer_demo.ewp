# IAR project hwtimer_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VMP12; USB_KW40ZK22F; BOARD_USE_VIRTUALCOM; DONGLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/utilities/inc/virtual_com; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK22F51212/include; ../../../../../platform/devices/MK22F51212/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../usb/adapter/sources; ../../../../../usb/adapter/sources/sdk; ../../../../../usb/usb_core/hal; ../../../../../usb/usb_core/include; ../../../../../usb/usb_core/device/include/MK22F51212; ../../../../../usb/usb_core/device/include; ../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../usb/usb_core/device/sources/classes/common; ../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../usb/usb_core/device/sources/classes/include; ../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../usb/usb_core/device/sources/controller; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hwtimer_demo.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK22F51212/linker/iar/MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K22F51212/debug/libksdk_platform.a; ../../../../../usb/usb_core/device/lib/bm/iar/MK22F51212/debug/libusbd_bm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VMP12; USB_KW40ZK22F; BOARD_USE_VIRTUALCOM; DONGLE
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K22F51212/release/libksdk_platform.a; ../../../../../usb/usb_core/device/lib/bm/iar/MK22F51212/release/libusbd_bm.a
  group startup
    ../../../../../platform/devices/MK22F51212/startup/iar/: startup_MK22F51212.s
    ../../../../../platform/devices/MK22F51212/startup/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/virtual_com/: usb_descriptor.c virtual_com.c
    ../../../../../platform/utilities/inc/virtual_com/: usb_descriptor.h virtual_com.h
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../: main.c
    ../../../../../platform/system/src/hwtimer/: fsl_hwtimer_systick_irq.c fsl_hwtimer_pit_irq.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
