# Keil uVision project hwtimer_demo.uvprojx, settings and files
target hwtimer_demo Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: hwtimer_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VMP12, USB_KW40ZK22F, BOARD_USE_VIRTUALCOM, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/utilities/inc/virtual_com;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MK22F51212/include;../../../../../platform/devices/MK22F51212/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../usb/adapter/sources;../../../../../usb/adapter/sources/sdk;../../../../../usb/usb_core/hal;../../../../../usb/usb_core/include;../../../../../usb/usb_core/device/include/MK22F51212;../../../../../usb/usb_core/device/include;../../../../../usb/usb_core/device/sources/classes/audio;../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../usb/usb_core/device/sources/classes/common;../../../../../usb/usb_core/device/sources/classes/composite;../../../../../usb/usb_core/device/sources/classes/hid;../../../../../usb/usb_core/device/sources/classes/include;../../../../../usb/usb_core/device/sources/classes/msd;../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../usb/usb_core/device/sources/controller/khci;../../../../../usb/usb_core/device/sources/controller;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../platform/devices/MK22F51212/linker/arm/MK22FN512xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K22F51212/debug/libksdk_platform.lib 
../../../../../usb/usb_core/device/lib/bm/mdk/MK22F51212/debug/libusbd_bm.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/src/virtual_com/: usb_descriptor.c virtual_com.c
    ../../../../../platform/utilities/inc/virtual_com/: usb_descriptor.h virtual_com.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MK22F51212/startup/arm/: startup_MK22F51212.s
    ../../../../../platform/devices/MK22F51212/startup/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c
    ../../../../../platform/system/src/hwtimer/: fsl_hwtimer_systick_irq.c fsl_hwtimer_pit_irq.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target hwtimer_demo Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: hwtimer_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VMP12, USB_KW40ZK22F, BOARD_USE_VIRTUALCOM, DONGLE
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K22F51212/release/libksdk_platform.lib 
../../../../../usb/usb_core/device/lib/bm/mdk/MK22F51212/release/libusbd_bm.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
