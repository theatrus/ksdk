# Keil uVision project mmdvsq_demo.uvprojx, settings and files
target mmdvsq_demo Debug (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: IROM(0x00000000,0x8000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: mmdvsq_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV10Z32VLF7, ARM_MATH_CM0PLUS, FRDM_KV10Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKV10Z7/include;../../../../../platform/devices/MKV10Z7/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;..;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1FFFF800 size 0x2000
  scatter file: ../../../../../platform/devices/MKV10Z7/linker/arm/MKV10Z32xxx7_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV10Z7/debug/libksdk_platform.lib 
../../../../../platform/CMSIS/Lib/ARM/arm_cortexM0l_math.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKV10Z7/startup/arm/: startup_MKV10Z7.s
    ../../../../../platform/devices/MKV10Z7/startup/: system_MKV10Z7.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c
    ../../../../../platform/system/src/hwtimer/: fsl_hwtimer_systick_irq.c fsl_hwtimer_pit_irq.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target mmdvsq_demo Release (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  cpu: as above
  output: mmdvsq_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV10Z32VLF7, ARM_MATH_CM0PLUS, FRDM_KV10Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-O0
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1FFFF800 size 0x2000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV10Z7/release/libksdk_platform.lib 
../../../../../platform/CMSIS/Lib/ARM/arm_cortexM0l_math.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
