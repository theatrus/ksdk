# Keil uVision project flash_demo.uvprojx, settings and files
target flash_demo Debug (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x800) IRAM2(0x20000000,0x1800) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: flash_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL33Z64VLH4, FRDM_KL43Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKL33Z644/include;../../../../../platform/devices/MKL33Z644/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;..;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: ../../../../../platform/devices/MKL33Z644/linker/arm/MKL33Z64xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL33Z644/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKL33Z644/startup/arm/: startup_MKL33Z644.s
    ../../../../../platform/devices/MKL33Z644/startup/: system_MKL33Z644.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c flash_swap.c
  group flash
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target flash_demo Release (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: as above
  output: flash_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL33Z64VLH4, FRDM_KL43Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL33Z644/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
