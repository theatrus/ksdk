# Keil uVision project i2c_rtos_freertos.uvprojx, settings and files
target i2c_rtos_freertos Debug (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x800) IRAM2(0x20000000,0x1800) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: i2c_rtos_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL33Z64VLH4, FSL_RTOS_FREE_RTOS, FRDM_KL43Z, FREEDOM
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../rtos/FreeRTOS/config/KL33Z644/mdk;../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKL33Z644/include;../../../../../../platform/devices/MKL33Z644/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../platform/drivers/src/i2c;../../../../../../rtos/FreeRTOS/include;../../../../../../rtos/FreeRTOS/src;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/KL33Z644/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: ../../../../../../platform/devices/MKL33Z644/linker/arm/MKL33Z64xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/KL33Z644/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__heap_size__=0x1200" 
--predefine="-D__stack_size__=0x100"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group free-rtos
    ../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../platform/devices/MKL33Z644/startup/arm/: startup_MKL33Z644.s
    ../../../../../../platform/devices/MKL33Z644/startup/: system_MKL33Z644.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: fsl_i2c_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target i2c_rtos_freertos Release (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.2
  cpu: as above
  output: i2c_rtos_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL33Z64VLH4, FSL_RTOS_FREE_RTOS, FRDM_KL43Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/KL33Z644/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/KL33Z644/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__heap_size__=0x1200" 
--predefine="-D__stack_size__=0x100"
