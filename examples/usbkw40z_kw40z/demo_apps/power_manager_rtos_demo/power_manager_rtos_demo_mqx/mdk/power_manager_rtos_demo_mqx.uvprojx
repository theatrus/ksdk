# Keil uVision project power_manager_rtos_demo_mqx.uvprojx, settings and files
target power_manager_rtos_demo_mqx Debug (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.1.0
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: power_manager_rtos_demo_mqx.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_MQX, USB_KW40Z, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/config  -J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx  -J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx_stdlib  -J#J
  c include: ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/config;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx_stdlib;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/nshell;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKW40Z4/include;../../../../../../platform/devices/MKW40Z4/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../../platform/drivers/src/uart;../../../../../../rtos/mqx/config/mcu/MKW40Z4;../../../../../../rtos/mqx/config/board/usbkw40z_kw40z;../..;../../../../../../platform/devices/MKW40Z4/include;../../../../../../platform/devices/MKW40Z4/startup;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/startup;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/mqx/source/include;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../../platform/devices/MKW40Z4/linker/arm/MKW40Z160xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_mqx_lib/mdk/KW40Z4/debug/libksdk_platform_mqx.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/nshell/lib_nshell.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx/lib_mqx.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x1500" 
--predefine="-D__heap_size__=0x1500" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MKW40Z4/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/usbkw40z_kw40z/: user_config.h
target power_manager_rtos_demo_mqx Release (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.1.0
  cpu: as above
  output: power_manager_rtos_demo_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKW40Z160VHT4, FSL_RTOS_MQX, USB_KW40Z, DONGLE
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/config  -J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx  -J../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx_stdlib  -J#J
  c include: ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/config;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx_stdlib;../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/nshell;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKW40Z4/include;../../../../../../platform/devices/MKW40Z4/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../../platform/drivers/src/uart;../../../../../../rtos/mqx/config/mcu/MKW40Z4;../../../../../../rtos/mqx/config/board/usbkw40z_kw40z;../..;../../../../../../platform/devices/MKW40Z4/include;../../../../../../platform/devices/MKW40Z4/startup;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/startup;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/mqx/source/include;../../../..
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_mqx_lib/mdk/KW40Z4/release/libksdk_platform_mqx.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/nshell/lib_nshell.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx/lib_mqx.lib 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../rtos/mqx/lib/usbkw40z_kw40z.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x1500" 
--predefine="-D__heap_size__=0x1500" 
--predefine="-D__ram_vector_table__=1"
