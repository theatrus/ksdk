# IAR project power_manager_rtos_demo_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKW40Z160VHT4; FSL_RTOS_MQX; USB_KW40Z; DONGLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/config; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx_stdlib; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/nshell; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKW40Z4/include; ../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart; ../../../../../../rtos/mqx/config/mcu/MKW40Z4; ../../../../../../rtos/mqx/config/board/usbkw40z_kw40z; ../..; ../../../../../../platform/devices/MKW40Z4/include; ../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager_rtos_demo_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_mqx_lib/iar/KW40Z4/debug/libksdk_platform_mqx.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/nshell/lib_nshell.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx/lib_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW40Z160VHT4; FSL_RTOS_MQX; USB_KW40Z; DONGLE
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/config; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx_stdlib; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/nshell; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKW40Z4/include; ../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../..; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../../platform/drivers/src/uart; ../../../../../../rtos/mqx/config/mcu/MKW40Z4; ../../../../../../rtos/mqx/config/board/usbkw40z_kw40z; ../..; ../../../../../../platform/devices/MKW40Z4/include; ../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/startup; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source/include; ../../../..
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_mqx_lib/iar/KW40Z4/release/libksdk_platform_mqx.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/nshell/lib_nshell.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx/lib_mqx.a
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MKW40Z4/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/usbkw40z_kw40z/: user_config.h
  group Config Files/Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
