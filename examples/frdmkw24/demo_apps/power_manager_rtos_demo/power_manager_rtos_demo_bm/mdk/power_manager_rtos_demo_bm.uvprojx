# Keil uVision project power_manager_rtos_demo_bm.uvprojx, settings and files
target power_manager_rtos_demo_bm Debug (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: power_manager_rtos_demo_bm.out +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG, CPU_MKW24D512VHA5, FSL_RTOS_BM, FRDM_KW24, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKW24D5/include;../../../../../../platform/devices/MKW24D5/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../platform/devices/MKW24D5/linker/arm/MKW24D512xxx5_flash.scf
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/KW24D5/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MKW24D5/startup/arm/: startup_MKW24D5.s
    ../../../../../../platform/devices/MKW24D5/startup/: system_MKW24D5.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_lptmr_irq.c fsl_rtc_irq.c fsl_adc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target power_manager_rtos_demo_bm Release (ARM-ADS)
  device: MKW24D512xxx5 Freescale
  cpu: as above
  output: power_manager_rtos_demo_bm.out +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKW24D512VHA5, FSL_RTOS_BM, FRDM_KW24, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/KW24D5/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
