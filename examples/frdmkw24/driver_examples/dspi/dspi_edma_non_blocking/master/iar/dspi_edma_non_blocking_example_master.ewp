# IAR project dspi_edma_non_blocking_example_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 Freescale MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../platform/osa/inc; ../../../../../../../platform/utilities/inc; ../../../../../../../platform/CMSIS/Include; ../../../../../../../platform/devices; ../../../../../../../platform/devices/MKW24D5/include; ../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../platform/hal/inc; ../../../../../../../platform/drivers/inc; ../../../../../../../platform/system/inc; ../../../../../../../platform/utilities/inc; ../../../../..; ../../../../../../../platform/drivers/src/dspi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dspi_edma_non_blocking_example_master.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../../../platform/devices/MKW24D5/linker/iar/MKW24D512xxx5_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/ksdk_platform_lib/iar/KW24D5/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW24D512VHA5; FRDM_KW24; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../lib/ksdk_platform_lib/iar/KW24D5/release/libksdk_platform.a
  group startup
    ../../../../../../../platform/devices/MKW24D5/startup/iar/: startup_MKW24D5.s
    ../../../../../../../platform/devices/MKW24D5/startup/: system_MKW24D5.c
    ../../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c fsl_dspi_edma_irq.c fsl_edma_irq.c
