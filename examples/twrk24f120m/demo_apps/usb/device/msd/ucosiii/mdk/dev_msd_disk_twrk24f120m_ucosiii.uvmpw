<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../usb/usb_core/device/build/mdk/usbd_sdk_twrk24f120m_ucosiii/usbd_sdk_twrk24f120m_ucosiii.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../lib/ksdk_ucosiii_lib/mdk/K24F25612/ksdk_ucosiii_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>dev_msd_disk_twrk24f120m_ucosiii.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
