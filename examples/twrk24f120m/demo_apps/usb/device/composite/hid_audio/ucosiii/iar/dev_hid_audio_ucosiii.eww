<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbd_sdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_audio_ucosiii</project><configuration>Debug</configuration></member><member><project>usbd_sdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>dev_hid_audio_ucosiii</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbd_sdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_audio_ucosiii</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbd_sdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>dev_hid_audio_ucosiii</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/device/lib/ucosiii/iar/MK24F25612/usbd_sdk_ucosiii_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_ucosiii_lib/iar/K24F25612/ksdk_ucosiii_lib.ewp</path></project><project><path>$WS_DIR$/dev_hid_audio_ucosiii.ewp</path></project></workspace>
