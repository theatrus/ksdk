# Keil uVision project power_manager_rtos_demo_mqx.uvprojx, settings and files
target power_manager_rtos_demo_mqx Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: power_manager_rtos_demo_mqx.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK24FN256VDC12, FSL_RTOS_MQX, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/config  -J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx  -J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx_stdlib  -J#J
  c include: ../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/config;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx_stdlib;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/nshell;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MK24F25612/include;../../../../../../platform/devices/MK24F25612/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../../platform/drivers/src/uart;../../../../../../rtos/mqx/config/mcu/MK24F25612;../../../../../../rtos/mqx/config/board/twrk24f120m;../..;../../../../../../platform/devices/MK24F25612/include;../../../../../../platform/devices/MK24F25612/startup;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/startup;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/mqx/source/include;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../platform/devices/MK24F25612/linker/arm/MK24FN256xxx12_flash.scf
  link misc: ../../../../../../lib/ksdk_mqx_lib/mdk/K24F25612/debug/libksdk_platform_mqx.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/nshell/lib_nshell.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx/lib_mqx.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group BSP Files
    ../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../rtos/mqx/config/mcu/MK24F25612/: mqx_sdk_config.h
    ../../../../../../rtos/mqx/config/board/twrk24f120m/: user_config.h
target power_manager_rtos_demo_mqx Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: power_manager_rtos_demo_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK24FN256VDC12, FSL_RTOS_MQX, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66 
-J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/config  -J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx  -J../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx_stdlib  -J#J
  c include: ../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/config;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx_stdlib;../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/nshell;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MK24F25612/include;../../../../../../platform/devices/MK24F25612/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../..;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../../platform/drivers/src/uart;../../../../../../rtos/mqx/config/mcu/MK24F25612;../../../../../../rtos/mqx/config/board/twrk24f120m;../..;../../../../../../platform/devices/MK24F25612/include;../../../../../../platform/devices/MK24F25612/startup;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/startup;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/mqx/source/include;../../../..
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_mqx_lib/mdk/K24F25612/release/libksdk_platform_mqx.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/nshell/lib_nshell.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx/lib_mqx.lib 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../rtos/mqx/lib/twrk24f120m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400" 
--predefine="-D__ram_vector_table__=1"
