# IAR project power_manager_rtos_demo_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 Freescale MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; TWR_K24F120M; TOWER; FSL_RTOS_UCOSIII
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MK24F25612/include; ../../../../../../platform/devices/MK24F25612/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/uCOSIII/src/config; ../../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../../platform/utilities/inc; ../../../..; ../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager_rtos_demo_ucosiii.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MK24F25612/linker/iar/MK24FN256xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosiii_lib/iar/K24F25612/debug/libksdk_platform_ucosiii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; TWR_K24F120M; TOWER; FSL_RTOS_UCOSIII
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosiii_lib/iar/K24F25612/release/libksdk_platform_ucosiii.a
  group ucosiii
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
    ../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group startup
    ../../../../../../platform/devices/MK24F25612/startup/iar/: startup_MK24F25612.s
    ../../../../../../platform/devices/MK24F25612/startup/: system_MK24F25612.c system_MK24F25612.h
    ../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h debug_console_lpm_callback.c fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c fsl_uart_irq.c main.c lpm_rtos.h lptmr_setup.c lptmr_setup.h register_callback.c rtc_setup.c rtc_setup.h rtos_lpm_callback.c task_led_toggle.c task_lpm.c task_lpm.h
