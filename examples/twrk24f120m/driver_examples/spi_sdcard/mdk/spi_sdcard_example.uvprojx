# Keil uVision project spi_sdcard_example.uvprojx, settings and files
target spi_sdcard_example Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: spi_sdcard_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK24FN256VDC12, PRINTF_FLOAT_ENABLE, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MK24F25612/include;../../../../../platform/devices/MK24F25612/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/drivers/src;../../../../../platform/composite/src/sdcard;../../../../../platform/composite/inc;../../../../../platform/drivers/src/dspi;../../../../../platform/drivers/src/edma;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../platform/devices/MK24F25612/linker/arm/MK24FN256xxx12_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K24F25612/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MK24F25612/startup/arm/: startup_MK24F25612.s
    ../../../../../platform/devices/MK24F25612/startup/: system_MK24F25612.c system_MK24F25612.h
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: fsl_dspi_irq.c main.c fsl_gpio_irq.c
    ../../../../../platform/composite/src/sdcard/: fsl_sdcard_spi.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target spi_sdcard_example Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: spi_sdcard_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK24FN256VDC12, PRINTF_FLOAT_ENABLE, TWR_K24F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K24F25612/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
