# Keil uVision project flexio_dspi_master_example.uvprojx, settings and files
target flexio_dspi_master_example Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: flexio_dspi_master_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../../platform/devices/MK80F25615/include;../../../../../../../platform/devices/MK80F25615/startup;../../../../../../../platform/hal/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/system/inc;../../../../../../../platform/drivers/src/edma;../../../../../../../platform/drivers/src/flexio;../../../../../../../platform/drivers/src/dspi;../../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../platform/devices/MK80F25615/linker/arm/MK80FN256xxx15_flash.scf
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K80F25615/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../platform/devices/MK80F25615/startup/arm/: startup_MK80F25615.s
    ../../../../../../../platform/devices/MK80F25615/startup/: system_MK80F25615.c system_MK80F25615.h
    ../../../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c fsl_edma_irq.c fsl_flexio_irq.c fsl_dspi_irq.c
  group board
    ../../: hardware_init.c
    ../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target flexio_dspi_master_example Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: as above
  output: flexio_dspi_master_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K80F25615/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
