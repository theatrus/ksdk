# Keil uVision project hello_world_qspi_alias.uvprojx, settings and files
target hello_world_qspi_alias Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: hello_world_qspi_alias.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, BOOTLOADER_CONFIG, TWR_K80F150M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MK80F25615/include;../../../../../platform/devices/MK80F25615/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../linker/MK80FN256xxx15_qspi_alias.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K80F25615/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group startup
    ../startup/arm/: startup_MK80F25615.s
    ../startup/: system_MK80F25615.h system_MK80F25615.c
    ../../../../../platform/devices/: startup.h startup.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../hello_world_qspi/: main.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target hello_world_qspi_alias Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: as above
  output: hello_world_qspi_alias.out
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VDC15, BOOTLOADER_CONFIG, TWR_K80F150M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../linker/MK80FN256xxx15_qspi_alias.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K80F25615/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
