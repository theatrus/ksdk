<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/device/lib/ucosii/mdk/MK80F25615/usbd_sdk_ucosii_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_ucosii_lib/mdk/K80F25615/ksdk_ucosii_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>dev_audio_generator_ucosii.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
