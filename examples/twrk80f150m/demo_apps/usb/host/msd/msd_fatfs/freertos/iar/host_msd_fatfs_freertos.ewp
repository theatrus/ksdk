# IAR project host_msd_fatfs_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK80FN256VDC15; USB_DISK_ENABLE=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../rtos/FreeRTOS/config/K80F25615/iar; ../../../../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK80F25615/include; ../../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MK80F25615; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MK80F25615; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller/ehci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/drivers/src/lpuart; ../../../../../../../../../platform/system/inc; ../../../../../device/video/flexio_ov7670/ov7670; ../..; ../../../../../../../../../platform/hal; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../../middleware/filesystem/fatfs; ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk; ../../../../../../../../../rtos/FreeRTOS/include; ../../../../../../../../../rtos/FreeRTOS/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../../../rtos/FreeRTOS/config/K80F25615/iar
  ILINK.IlinkOutputFile: host_msd_fatfs_freertos.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MK80F25615/linker/iar/MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/freertos/iar/MK80F25615/debug/libusbh_freertos.a; ../../../../../../../../../lib/ksdk_freertos_lib/iar/K80F25615/debug/libksdk_platform_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK80FN256VDC15; USB_DISK_ENABLE=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/freertos/iar/MK80F25615/release/libusbh_freertos.a; ../../../../../../../../../lib/ksdk_freertos_lib/iar/K80F25615/release/libksdk_platform_freertos.a
  group free-rtos
    ../../../../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../../../../platform/devices/MK80F25615/startup/iar/: startup_MK80F25615.s
    ../../../../../../../../../platform/devices/MK80F25615/startup/: system_MK80F25615.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: main.c msd_fat_demo.c
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources/fatfs
    ../../../../../../../../../middleware/filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources/fatfs/option
    ../../../../../../../../../middleware/filesystem/fatfs/option/: unicode.c
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
