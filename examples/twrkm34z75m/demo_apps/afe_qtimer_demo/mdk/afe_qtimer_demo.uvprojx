# Keil uVision project afe_qtimer_demo.uvprojx, settings and files
target afe_qtimer_demo Debug (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KMxx_DFP.1.1.7
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: afe_qtimer_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKM34Z256VLQ7, TWR_KM34Z75M, TOWER
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKM34Z7/include;../../../../../platform/devices/MKM34Z7/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../freemaster;..;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ../../../../../platform/devices/MKM34Z7/linker/arm/MKM34Z256xxx7_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KM34Z7/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKM34Z7/startup/arm/: startup_MKM34Z7.s
    ../../../../../platform/devices/MKM34Z7/startup/: system_MKM34Z7.c system_MKM34Z7.h
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c fsl_afe_irq.c freemaster_cfg.h
  group freemaster
    ../freemaster/: freemaster_appcmd.c freemaster_bdm.c freemaster_defcfg.h freemaster_Kxx.c freemaster_Kxx.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c freemaster_tsa.h
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
target afe_qtimer_demo Release (ARM-ADS)
  device: MKM34Z256xxx7 Freescale
  pack: Keil.Kinetis_KMxx_DFP.1.1.7
  cpu: as above
  output: afe_qtimer_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKM34Z256VLQ7, TWR_KM34Z75M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KM34Z7/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
