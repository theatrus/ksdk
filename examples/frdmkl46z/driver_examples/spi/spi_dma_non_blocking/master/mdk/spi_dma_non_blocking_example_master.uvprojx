# Keil uVision project spi_dma_non_blocking_example_master.uvprojx, settings and files
target spi_dma_non_blocking_example_master Debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: spi_dma_non_blocking_example_master.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../platform/hal/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/system/inc;../../../../../../../platform/utilities/inc;../../../../..;../../../../../../../platform/drivers/src/spi
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../../../platform/devices/MKL46Z4/linker/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/KL46Z4/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../platform/devices/MKL46Z4/startup/arm/: startup_MKL46Z4.s
    ../../../../../../../platform/devices/MKL46Z4/startup/: system_MKL46Z4.c
    ../../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c fsl_spi_dma_irq.c fsl_dma_irq.c
target spi_dma_non_blocking_example_master Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: as above
  output: spi_dma_non_blocking_example_master.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/KL46Z4/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
