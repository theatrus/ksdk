# Keil uVision project host_cdc_serial_bm.uvprojx, settings and files
target host_cdc_serial_bm Debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: host_cdc_serial_bm.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MKL46Z256VLL4, CLOCK_SETUP=4, FRDM_KL46Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../../../platform/osa/inc;../../../../../../../../../rtos;../../../../../../../../../platform/utilities/inc;../../../../../../../../../platform/CMSIS/Include;../../../../../../../../../platform/devices;../../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../..;../../../../../../../../../usb/adapter/sources;../../../../../../../../../usb/adapter/sources/sdk;../../../../../../../../../usb/usb_core/device/include/MKL46Z4;../../../../../../../../../usb/usb_core/device/include;../../../../../../../../../usb/usb_core/device/sources/classes/audio;../../../../../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../../../../../usb/usb_core/device/sources/classes/common;../../../../../../../../../usb/usb_core/device/sources/classes/composite;../../../../../../../../../usb/usb_core/device/sources/classes/hid;../../../../../../../../../usb/usb_core/device/sources/classes/include;../../../../../../../../../usb/usb_core/device/sources/classes/include/config;../../../../../../../../../usb/usb_core/device/sources/classes/msd;../../../../../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../../../../../usb/usb_core/device/sources/classes/video;../../../../../../../../../usb/usb_core/device/sources/controller/khci;../../../../../../../../../usb/usb_core/device/sources/controller;../../../../../../../../../usb/usb_core/hal;../../../../../../../../../usb/usb_core/host/include/MKL46Z4;../../../../../../../../../usb/usb_core/host/include;../../../../../../../../../usb/usb_core/host/sources/classes/audio;../../../../../../../../../usb/usb_core/host/sources/classes/cdc;../../../../../../../../../usb/usb_core/host/sources/classes/hid;../../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../../usb/usb_core/host/sources/classes/phdc;../../../../../../../../../usb/usb_core/host/sources/classes/printer;../../../../../../../../../usb/usb_core/host/sources/controller/khci;../../../../../../../../../usb/usb_core/host/sources/controller;../../../../../../../../../usb/usb_core/include;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/gpio;../../../../../../../../../platform/drivers/src/pit;../../../../../../../../../platform/drivers/src/dma;../../../../../../../../../platform/system/inc;../..;../../../../../../../../../platform/drivers/src/uart;../../../../../../../../../platform/drivers/src/i2c;../../../../../../../../../usb/facility/include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../../../../../platform/devices/MKL46Z4/linker/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../../../../../../usb/usb_core/host/lib/bm/mdk/MKL46Z4/debug/libusbh_bm.lib 
../../../../../../../../../lib/ksdk_platform_lib/mdk/KL46Z4/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../../platform/devices/MKL46Z4/startup/arm/: startup_MKL46Z4.s
    ../../../../../../../../../platform/devices/MKL46Z4/startup/: system_MKL46Z4.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group facility
    ../../../../../../../../../usb/facility/include/: usb_uart_drv.h
    ../../../../../../../../../usb/facility/lpsci/: usb_uart_drv.c
  group sources
    ../../: cdc_serial.c cdc_serial.h usb_host_cdc_io.c usb_host_cdc_io.h
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
target host_cdc_serial_bm Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: as above
  output: host_cdc_serial_bm.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MKL46Z256VLL4, CLOCK_SETUP=4, FRDM_KL46Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../../../../../usb/usb_core/host/lib/bm/mdk/MKL46Z4/release/libusbh_bm.lib 
../../../../../../../../../lib/ksdk_platform_lib/mdk/KL46Z4/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
