<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbh_sdk_frdmkl46z_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>host_phdc_frdmkl46z_bm</project><configuration>Debug</configuration></member><member><project>usbh_sdk_frdmkl46z_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>host_phdc_frdmkl46z_bm</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_sdk_frdmkl46z_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>host_phdc_frdmkl46z_bm</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_sdk_frdmkl46z_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>host_phdc_frdmkl46z_bm</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/build/iar/usbh_sdk_frdmkl46z_bm/usbh_sdk_frdmkl46z_bm.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_platform_lib/iar/KL46Z4/ksdk_platform_lib.ewp</path></project><project><path>$WS_DIR$/host_phdc_frdmkl46z_bm.ewp</path></project></workspace>
