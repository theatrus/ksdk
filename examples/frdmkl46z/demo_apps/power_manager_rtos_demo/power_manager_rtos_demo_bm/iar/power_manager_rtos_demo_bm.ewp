# IAR project power_manager_rtos_demo_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLL4; FSL_RTOS_BM; FRDM_KL46Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL46Z4/include; ../../../../../../platform/devices/MKL46Z4/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../..; ../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager_rtos_demo_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKL46Z4/linker/iar/MKL46Z256xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KL46Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL46Z256VLL4; FSL_RTOS_BM; FRDM_KL46Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KL46Z4/release/libksdk_platform.a
  group startup
    ../../../../../../platform/devices/MKL46Z4/startup/iar/: startup_MKL46Z4.s
    ../../../../../../platform/devices/MKL46Z4/startup/: system_MKL46Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_lptmr_irq.c fsl_rtc_irq.c fsl_adc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
