<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../lib/ksdk_ucosii_lib/mdk/KW24D5/ksdk_ucosii_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>power_manager_rtos_demo_ucosii.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
