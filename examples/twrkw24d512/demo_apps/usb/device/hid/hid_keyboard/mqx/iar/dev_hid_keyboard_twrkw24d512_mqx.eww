<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>mqx_twrkw24d512</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrkw24d512</project><configuration>debug</configuration></member><member><project>usbd_sdk_twrkw24d512_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_keyboard_twrkw24d512_mqx</project><configuration>Debug</configuration></member><member><project>mqx_twrkw24d512</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrkw24d512</project><configuration>release</configuration></member><member><project>usbd_sdk_twrkw24d512_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>dev_hid_keyboard_twrkw24d512_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>mqx_twrkw24d512</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrkw24d512</project><configuration>debug</configuration></member><member><project>usbd_sdk_twrkw24d512_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_keyboard_twrkw24d512_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>mqx_twrkw24d512</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrkw24d512</project><configuration>release</configuration></member><member><project>usbd_sdk_twrkw24d512_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>dev_hid_keyboard_twrkw24d512_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx/build/iar/mqx_twrkw24d512/mqx_twrkw24d512.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_twrkw24d512/mqx_stdlib_twrkw24d512.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/device/build/iar/usbd_sdk_twrkw24d512_mqx/usbd_sdk_twrkw24d512_mqx.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_mqx_lib/iar/KW24D5/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/dev_hid_keyboard_twrkw24d512_mqx.ewp</path></project></workspace>
