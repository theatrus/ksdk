# IAR project flash_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK64F12/include; ../../../../../platform/devices/MK64F12/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../platform/utilities/inc; ../../..; ../../../../../platform/drivers/src/flash; ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flash_example.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK64F12/linker/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K64F12/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K64F12/release/libksdk_platform.a
  group startup
    ../../../../../platform/devices/MK64F12/startup/iar/: startup_MK64F12.s
    ../../../../../platform/devices/MK64F12/startup/: system_MK64F12.c
    ../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashVerifySection.c
