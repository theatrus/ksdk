# Keil uVision project dspi_edma_non_blocking_example_master.uvprojx, settings and files
target dspi_edma_non_blocking_example_master Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: dspi_edma_non_blocking_example_master.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../../platform/devices/MK64F12/include;../../../../../../../platform/devices/MK64F12/startup;../../../../../../../platform/hal/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/system/inc;../../../../../../../platform/utilities/inc;../../../../..;../../../../../../../platform/drivers/src/dspi
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../platform/devices/MK64F12/linker/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K64F12/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../platform/devices/MK64F12/startup/arm/: startup_MK64F12.s
    ../../../../../../../platform/devices/MK64F12/startup/: system_MK64F12.c
    ../../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c fsl_dspi_edma_irq.c fsl_edma_irq.c
target dspi_edma_non_blocking_example_master Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: dspi_edma_non_blocking_example_master.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K64F12/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
