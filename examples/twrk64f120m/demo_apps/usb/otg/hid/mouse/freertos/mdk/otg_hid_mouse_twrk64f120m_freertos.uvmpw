<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/otg/build/mdk/usbotg_sdk_twrk64f120m_freertos/usbotg_sdk_twrk64f120m_freertos.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_freertos_lib/mdk/K64F12/ksdk_freertos_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>otg_hid_mouse_twrk64f120m_freertos.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
