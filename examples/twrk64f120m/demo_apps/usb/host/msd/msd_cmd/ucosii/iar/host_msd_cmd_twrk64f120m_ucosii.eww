<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbh_sdk_twrk64f120m_ucosii</project><configuration>Debug</configuration></member><member><project>ksdk_ucosii_lib</project><configuration>Debug</configuration></member><member><project>host_msd_cmd_twrk64f120m_ucosii</project><configuration>Debug</configuration></member><member><project>usbh_sdk_twrk64f120m_ucosii</project><configuration>Release</configuration></member><member><project>ksdk_ucosii_lib</project><configuration>Release</configuration></member><member><project>host_msd_cmd_twrk64f120m_ucosii</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_sdk_twrk64f120m_ucosii</project><configuration>Debug</configuration></member><member><project>ksdk_ucosii_lib</project><configuration>Debug</configuration></member><member><project>host_msd_cmd_twrk64f120m_ucosii</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_sdk_twrk64f120m_ucosii</project><configuration>Release</configuration></member><member><project>ksdk_ucosii_lib</project><configuration>Release</configuration></member><member><project>host_msd_cmd_twrk64f120m_ucosii</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/build/iar/usbh_sdk_twrk64f120m_ucosii/usbh_sdk_twrk64f120m_ucosii.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_ucosii_lib/iar/K64F12/ksdk_ucosii_lib.ewp</path></project><project><path>$WS_DIR$/host_msd_cmd_twrk64f120m_ucosii.ewp</path></project></workspace>
