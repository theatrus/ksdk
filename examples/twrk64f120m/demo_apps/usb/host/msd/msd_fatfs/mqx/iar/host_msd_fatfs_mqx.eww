<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbh_sdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>mqx_twrk64f120m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>debug</configuration></member><member><project>host_msd_fatfs_mqx</project><configuration>Debug</configuration></member><member><project>usbh_sdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_twrk64f120m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>release</configuration></member><member><project>host_msd_fatfs_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_sdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>mqx_twrk64f120m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>debug</configuration></member><member><project>host_msd_fatfs_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_sdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_twrk64f120m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>release</configuration></member><member><project>host_msd_fatfs_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/lib/mqx/iar/MK64F12/usbh_sdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx/build/iar/mqx_twrk64f120m/mqx_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_twrk64f120m/mqx_stdlib_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/host_msd_fatfs_mqx.ewp</path></project></workspace>
