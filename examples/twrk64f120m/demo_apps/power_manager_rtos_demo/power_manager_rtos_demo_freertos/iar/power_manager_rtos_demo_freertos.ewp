# IAR project power_manager_rtos_demo_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/FreeRTOS/config/K64F12/iar; ../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MK64F12/include; ../../../../../../platform/devices/MK64F12/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../..; ../../../../../../rtos/FreeRTOS/include; ../../../../../../rtos/FreeRTOS/src; ../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../rtos/FreeRTOS/config/K64F12/iar
  ILINK.IlinkOutputFile: power_manager_rtos_demo_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MK64F12/linker/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_freertos_lib/iar/K64F12/debug/libksdk_platform_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; FSL_RTOS_FREE_RTOS; TWR_K64F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_freertos_lib/iar/K64F12/release/libksdk_platform_freertos.a
  group free-rtos
    ../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../platform/devices/MK64F12/startup/iar/: startup_MK64F12.s
    ../../../../../../platform/devices/MK64F12/startup/: system_MK64F12.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c lpm_rtos.h lptmr_setup.c lptmr_setup.h rtc_setup.c rtc_setup.h main.c task_lpm.c task_lpm.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
