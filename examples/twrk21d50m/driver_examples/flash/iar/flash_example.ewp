# IAR project flash_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK21DN512AVMC5; TWR_K21D50M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK21DA5/include; ../../../../../platform/devices/MK21DA5/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../../../platform/drivers/src/flash; ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flash_example.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK21DA5/linker/iar/MK21DN512Axxx5_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K21DA5/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK21DN512AVMC5; TWR_K21D50M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K21DA5/release/libksdk_platform.a
  group startup
    ../../../../../platform/devices/MK21DA5/startup/iar/: startup_MK21DA5.s
    ../../../../../platform/devices/MK21DA5/startup/: system_MK21DA5.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashVerifySection.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
