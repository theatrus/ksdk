# Keil uVision project dspi_edma_blocking_example_master.uvprojx, settings and files
target dspi_edma_blocking_example_master Debug (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: dspi_edma_blocking_example_master.out +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG, CPU_MK21DN512AVMC5, TWR_K21D50M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../../platform/devices/MK21DA5/include;../../../../../../../platform/devices/MK21DA5/startup;../../../../../../../platform/hal/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/system/inc;../../../../../../../platform/utilities/inc;../../../../..;../../../../../../../platform/drivers/src/dspi
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../platform/devices/MK21DA5/linker/arm/MK21DN512Axxx5_flash.scf
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K21DA5/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../platform/devices/MK21DA5/startup/arm/: startup_MK21DA5.s
    ../../../../../../../platform/devices/MK21DA5/startup/: system_MK21DA5.c
    ../../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c fsl_dspi_edma_irq.c fsl_edma_irq.c
target dspi_edma_blocking_example_master Release (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: as above
  output: dspi_edma_blocking_example_master.out +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK21DN512AVMC5, TWR_K21D50M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../../lib/ksdk_platform_lib/mdk/K21DA5/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
