# IAR project host_msd_fatfs_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK21DN512AVMC5; USB_DISK_ENABLE=1; FSL_RTOS_MQX; TWR_K21D50M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug/config; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug/mqx; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug/mqx_stdlib; ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK21DA5/include; ../../../../../../../../../platform/devices/MK21DA5/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MK21DA5; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MK21DA5; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/drivers/src/lpuart; ../../../../../../../../../platform/system/inc; ../..; ../../../../../../../../../platform/hal; ../../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../../middleware/filesystem/fatfs; ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk; ../../../../../../../../../rtos/mqx/config/mcu/MK21DA5; ../../../../../../../../../rtos/mqx/config/board/twrk21d50m; ../..; ../../../../../../../../../platform/devices/MK21DA5/include; ../../../../../../../../../platform/devices/MK21DA5/startup; ../../../../../../../../../platform/system/inc; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../../platform/startup; ../../../../../../../../../rtos/mqx/config/common; ../../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../../rtos/mqx/mqx/source/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_msd_fatfs_mqx.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x1000; __heap_size__=0x4000
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MK21DA5/linker/iar/MK21DN512Axxx5_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/mqx/iar/MK21DA5/debug/libusbh_mqx.a; ../../../../../../../../../lib/ksdk_mqx_lib/iar/K21DA5/debug/libksdk_platform_mqx.a; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug/mqx/lib_mqx.a; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK21DN512AVMC5; USB_DISK_ENABLE=1; FSL_RTOS_MQX; TWR_K21D50M; TOWER
  ICCARM.CCIncludePath2: ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release/config; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release/mqx; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release/mqx_stdlib; ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK21DA5/include; ../../../../../../../../../platform/devices/MK21DA5/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MK21DA5; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MK21DA5; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/drivers/src/lpuart; ../../../../../../../../../platform/system/inc; ../..; ../../../../../../../../../platform/hal; ../../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../../middleware/filesystem/fatfs; ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk; ../../../../../../../../../rtos/mqx/config/mcu/MK21DA5; ../../../../../../../../../rtos/mqx/config/board/twrk21d50m; ../..; ../../../../../../../../../platform/devices/MK21DA5/include; ../../../../../../../../../platform/devices/MK21DA5/startup; ../../../../../../../../../platform/system/inc; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../../platform/startup; ../../../../../../../../../rtos/mqx/config/common; ../../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../../rtos/mqx/mqx/source/include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/mqx/iar/MK21DA5/release/libusbh_mqx.a; ../../../../../../../../../lib/ksdk_mqx_lib/iar/K21DA5/release/libksdk_platform_mqx.a; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release/mqx/lib_mqx.a; ../../../../../../../../../rtos/mqx/lib/twrk21d50m.iar/release/mqx_stdlib/lib_mqx_stdlib.a
  group sources
    ../../: main.c msd_fat_demo.c
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources/fatfs
    ../../../../../../../../../middleware/filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources/fatfs/option
    ../../../../../../../../../middleware/filesystem/fatfs/option/: unicode.c
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group BSP Files
    ../../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../../../../rtos/mqx/config/mcu/MK21DA5/: mqx_sdk_config.h
    ../../../../../../../../../rtos/mqx/config/board/twrk21d50m/: user_config.h
  group Config Files/Common
    ../../../../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
