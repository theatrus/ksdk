# Keil uVision project host_msd_fatfs_mqx.uvprojx, settings and files
target host_msd_fatfs_mqx Debug (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: host_msd_fatfs_mqx.out +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1, CPU_MK21DN512AVMC5, USB_DISK_ENABLE=1, FSL_RTOS_MQX, TWR_K21D50M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/config;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx_stdlib;../../../../../../../../../platform/osa/inc;../../../../../../../../../rtos;../../../../../../../../../platform/utilities/inc;../../../../../../../../../platform/CMSIS/Include;../../../../../../../../../platform/devices;../../../../../../../../../platform/devices/MK21DA5/include;../../../../../../../../../platform/devices/MK21DA5/startup;../../../../../../..;../../../../../../../../../usb/adapter/sources;../../../../../../../../../usb/adapter/sources/sdk;../../../../../../../../../usb/usb_core/device/include/MK21DA5;../../../../../../../../../usb/usb_core/device/include;../../../../../../../../../usb/usb_core/device/sources/classes/audio;../../../../../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../../../../../usb/usb_core/device/sources/classes/common;../../../../../../../../../usb/usb_core/device/sources/classes/composite;../../../../../../../../../usb/usb_core/device/sources/classes/hid;../../../../../../../../../usb/usb_core/device/sources/classes/include;../../../../../../../../../usb/usb_core/device/sources/classes/include/config;../../../../../../../../../usb/usb_core/device/sources/classes/msd;../../../../../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../../../../../usb/usb_core/device/sources/classes/video;../../../../../../../../../usb/usb_core/device/sources/controller/khci;../../../../../../../../../usb/usb_core/device/sources/controller;../../../../../../../../../usb/usb_core/hal;../../../../../../../../../usb/usb_core/host/include/MK21DA5;../../../../../../../../../usb/usb_core/host/include;../../../../../../../../../usb/usb_core/host/sources/classes/audio;../../../../../../../../../usb/usb_core/host/sources/classes/cdc;../../../../../../../../../usb/usb_core/host/sources/classes/hid;../../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../../usb/usb_core/host/sources/classes/phdc;../../../../../../../../../usb/usb_core/host/sources/classes/printer;../../../../../../../../../usb/usb_core/host/sources/controller/khci;../../../../../../../../../usb/usb_core/host/sources/controller;../../../../../../../../../usb/usb_core/include;../../../../../../../../../usb/usb_core/otg/sources/driver/khci;../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk;../../../../../../../../../usb/usb_core/otg/include;../../../../../../../../../usb/usb_core/otg/sources/otg;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/uart;../../../../../../../../../platform/drivers/src/gpio;../../../../../../../../../platform/drivers/src/pit;../../../../../../../../../platform/drivers/src/edma;../../../../../../../../../platform/drivers/src/lpuart;../../../../../../../../../platform/system/inc;../..;../../../../../../../../../platform/hal;../../../../../../../../../platform/drivers/src/i2c;../../../../../../../../../middleware/filesystem/fatfs;../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk;../../../../../../../../../rtos/mqx/config/mcu/MK21DA5;../../../../../../../../../rtos/mqx/config/board/twrk21d50m;../..;../../../../../../../../../platform/devices/MK21DA5/include;../../../../../../../../../platform/devices/MK21DA5/startup;../../../../../../../../../platform/system/inc;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/mpu;../../../../../../../../../platform/startup;../../../../../../../../../rtos/mqx/config/common;../../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../../rtos/mqx/mqx/source/include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../../../platform/devices/MK21DA5/linker/arm/MK21DN512Axxx5_flash.scf
  link misc: ../../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK21DA5/debug/libusbh_mqx.lib 
../../../../../../../../../lib/ksdk_mqx_lib/mdk/K21DA5/debug/libksdk_platform_mqx.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group sources
    ../../: main.c msd_fat_demo.c
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources:fatfs
    ../../../../../../../../../middleware/filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources:fatfs:option
    ../../../../../../../../../middleware/filesystem/fatfs/option/: unicode.c
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group BSP Files
    ../../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../../../../rtos/mqx/config/mcu/MK21DA5/: mqx_sdk_config.h
    ../../../../../../../../../rtos/mqx/config/board/twrk21d50m/: user_config.h
target host_msd_fatfs_mqx Release (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: as above
  output: host_msd_fatfs_mqx.out +hex
  c flags: Optim=4 OneElfS=1
  c define: _DEBUG=0, CPU_MK21DN512AVMC5, USB_DISK_ENABLE=1, FSL_RTOS_MQX, TWR_K21D50M, TOWER
  c misc: as above
  c include: ../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/config;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx;../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx_stdlib;../../../../../../../../../platform/osa/inc;../../../../../../../../../rtos;../../../../../../../../../platform/utilities/inc;../../../../../../../../../platform/CMSIS/Include;../../../../../../../../../platform/devices;../../../../../../../../../platform/devices/MK21DA5/include;../../../../../../../../../platform/devices/MK21DA5/startup;../../../../../../..;../../../../../../../../../usb/adapter/sources;../../../../../../../../../usb/adapter/sources/sdk;../../../../../../../../../usb/usb_core/device/include/MK21DA5;../../../../../../../../../usb/usb_core/device/include;../../../../../../../../../usb/usb_core/device/sources/classes/audio;../../../../../../../../../usb/usb_core/device/sources/classes/cdc;../../../../../../../../../usb/usb_core/device/sources/classes/common;../../../../../../../../../usb/usb_core/device/sources/classes/composite;../../../../../../../../../usb/usb_core/device/sources/classes/hid;../../../../../../../../../usb/usb_core/device/sources/classes/include;../../../../../../../../../usb/usb_core/device/sources/classes/include/config;../../../../../../../../../usb/usb_core/device/sources/classes/msd;../../../../../../../../../usb/usb_core/device/sources/classes/phdc;../../../../../../../../../usb/usb_core/device/sources/classes/video;../../../../../../../../../usb/usb_core/device/sources/controller/khci;../../../../../../../../../usb/usb_core/device/sources/controller;../../../../../../../../../usb/usb_core/hal;../../../../../../../../../usb/usb_core/host/include/MK21DA5;../../../../../../../../../usb/usb_core/host/include;../../../../../../../../../usb/usb_core/host/sources/classes/audio;../../../../../../../../../usb/usb_core/host/sources/classes/cdc;../../../../../../../../../usb/usb_core/host/sources/classes/hid;../../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../../usb/usb_core/host/sources/classes/phdc;../../../../../../../../../usb/usb_core/host/sources/classes/printer;../../../../../../../../../usb/usb_core/host/sources/controller/khci;../../../../../../../../../usb/usb_core/host/sources/controller;../../../../../../../../../usb/usb_core/include;../../../../../../../../../usb/usb_core/otg/sources/driver/khci;../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk;../../../../../../../../../usb/usb_core/otg/include;../../../../../../../../../usb/usb_core/otg/sources/otg;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/uart;../../../../../../../../../platform/drivers/src/gpio;../../../../../../../../../platform/drivers/src/pit;../../../../../../../../../platform/drivers/src/edma;../../../../../../../../../platform/drivers/src/lpuart;../../../../../../../../../platform/system/inc;../..;../../../../../../../../../platform/hal;../../../../../../../../../platform/drivers/src/i2c;../../../../../../../../../middleware/filesystem/fatfs;../../../../../../../../../middleware/filesystem/fatfs/fsl_usb_disk;../../../../../../../../../rtos/mqx/config/mcu/MK21DA5;../../../../../../../../../rtos/mqx/config/board/twrk21d50m;../..;../../../../../../../../../platform/devices/MK21DA5/include;../../../../../../../../../platform/devices/MK21DA5/startup;../../../../../../../../../platform/system/inc;../../../../../../../../../platform/hal/inc;../../../../../../../../../platform/drivers/inc;../../../../../../../../../platform/drivers/src/mpu;../../../../../../../../../platform/startup;../../../../../../../../../rtos/mqx/config/common;../../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../../rtos/mqx/mqx/source/include
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK21DA5/release/libusbh_mqx.lib 
../../../../../../../../../lib/ksdk_mqx_lib/mdk/K21DA5/release/libksdk_platform_mqx.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../../rtos/mqx/lib/twrk21d50m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x1000" 
--predefine="-D__heap_size__=0x4000"
