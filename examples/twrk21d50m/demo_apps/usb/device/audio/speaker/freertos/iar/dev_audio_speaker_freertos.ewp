# IAR project dev_audio_speaker_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK21DN512AVMC5; FSL_RTOS_FREE_RTOS; TWR_K21D50M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../rtos/FreeRTOS/config/K21DA5/iar; ../../../../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK21DA5/include; ../../../../../../../../../platform/devices/MK21DA5/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MK21DA5; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MK21DA5; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/drivers/src/lpuart; ../../../../../../../../../platform/system/inc; ../..; ../../../../../../../../../platform/composite/inc; ../../../../../../../../../rtos/FreeRTOS/include; ../../../../../../../../../rtos/FreeRTOS/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../../../rtos/FreeRTOS/config/K21DA5/iar
  ILINK.IlinkOutputFile: dev_audio_speaker_freertos.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x1000; __heap_size__=0x4000
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MK21DA5/linker/iar/MK21DN512Axxx5_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/device/lib/freertos/iar/MK21DA5/debug/libusbd_freertos.a; ../../../../../../../../../lib/ksdk_freertos_lib/iar/K21DA5/debug/libksdk_platform_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK21DN512AVMC5; FSL_RTOS_FREE_RTOS; TWR_K21D50M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/device/lib/freertos/iar/MK21DA5/release/libusbd_freertos.a; ../../../../../../../../../lib/ksdk_freertos_lib/iar/K21DA5/release/libksdk_platform_freertos.a
  group free-rtos
    ../../../../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../../../../platform/devices/MK21DA5/startup/iar/: startup_MK21DA5.s
    ../../../../../../../../../platform/devices/MK21DA5/startup/: system_MK21DA5.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources/soundcard
    ../../../../../../../../../platform/composite/inc/: fsl_soundcard.h
    ../../../../../../../../../platform/composite/src/soundcard/: fsl_soundcard.c
  group sources/codec
    ../../: fsl_sgtl5000_driver.c fsl_sgtl5000_driver.h
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
