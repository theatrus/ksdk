# Keil uVision project flash_demo.uvprojx, settings and files
target flash_demo Debug (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(50000000) ELITTLE
  output: flash_demo.out +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG, CPU_MK21DN512AVMC5, TWR_K21D50M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MK21DA5/include;../../../../../platform/devices/MK21DA5/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;..;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../platform/devices/MK21DA5/linker/arm/MK21DN512Axxx5_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K21DA5/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MK21DA5/startup/arm/: startup_MK21DA5.s
    ../../../../../platform/devices/MK21DA5/startup/: system_MK21DA5.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c flash_swap.c
  group flash
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target flash_demo Release (ARM-ADS)
  device: MK21DN512xxx5 Freescale
  cpu: as above
  output: flash_demo.out +hex
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK21DN512AVMC5, TWR_K21D50M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/K21DA5/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
