<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_ucosii_lib</project><configuration>Release</configuration></member><member><project>power_manager_rtos_demo_ucosii</project><configuration>Release</configuration></member><member><project>ksdk_ucosii_lib</project><configuration>Debug</configuration></member><member><project>power_manager_rtos_demo_ucosii</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_ucosii_lib</project><configuration>Release</configuration></member><member><project>power_manager_rtos_demo_ucosii</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_ucosii_lib</project><configuration>Debug</configuration></member><member><project>power_manager_rtos_demo_ucosii</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../lib/ksdk_ucosii_lib/iar/K21DA5/ksdk_ucosii_lib.ewp</path></project><project><path>$WS_DIR$/power_manager_rtos_demo_ucosii.ewp</path></project></workspace>
