# Keil uVision project power_manager_rtos_demo_ucosiii.uvprojx, settings and files
target power_manager_rtos_demo_ucosiii Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: power_manager_rtos_demo_ucosiii.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL43Z256VLH4, FSL_RTOS_UCOSIII, FRDM_KL43Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView;../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/RealView;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKL43Z4/include;../../../../../../platform/devices/MKL43Z4/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../../../../../../rtos/uCOSIII/src/config;../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../platform/utilities/inc;../../../..;../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../../platform/devices/MKL43Z4/linker/arm/MKL43Z256xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_ucosiii_lib/mdk/KL43Z4/debug/libksdk_platform_ucosiii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group ucosiii
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/RealView/: cpu_c.c cpu_a.s
    ../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MKL43Z4/startup/arm/: startup_MKL43Z4.s
    ../../../../../../platform/devices/MKL43Z4/startup/: system_MKL43Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h debug_console_lpm_callback.c fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c fsl_uart_irq.c main.c lpm_rtos.h lptmr_setup.c lptmr_setup.h register_callback.c rtc_setup.c rtc_setup.h rtos_lpm_callback.c task_led_toggle.c task_lpm.c task_lpm.h
target power_manager_rtos_demo_ucosiii Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: as above
  output: power_manager_rtos_demo_ucosiii.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL43Z256VLH4, FSL_RTOS_UCOSIII, FRDM_KL43Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_ucosiii_lib/mdk/KL43Z4/release/libksdk_platform_ucosiii.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
