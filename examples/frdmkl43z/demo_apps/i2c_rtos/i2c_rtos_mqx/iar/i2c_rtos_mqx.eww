<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>nshell_frdmkl43z</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmkl43z</project><configuration>release</configuration></member><member><project>mqx_frdmkl43z</project><configuration>release</configuration></member><member><project>i2c_rtos_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>nshell_frdmkl43z</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmkl43z</project><configuration>debug</configuration></member><member><project>mqx_frdmkl43z</project><configuration>debug</configuration></member><member><project>i2c_rtos_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>nshell_frdmkl43z</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmkl43z</project><configuration>release</configuration></member><member><project>mqx_frdmkl43z</project><configuration>release</configuration></member><member><project>i2c_rtos_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>nshell_frdmkl43z</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmkl43z</project><configuration>debug</configuration></member><member><project>mqx_frdmkl43z</project><configuration>debug</configuration></member><member><project>i2c_rtos_mqx</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../lib/ksdk_mqx_lib/iar/KL43Z4/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/nshell/build/iar/nshell_frdmkl43z/nshell_frdmkl43z.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_frdmkl43z/mqx_stdlib_frdmkl43z.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/mqx/build/iar/mqx_frdmkl43z/mqx_frdmkl43z.ewp</path></project><project><path>$WS_DIR$/i2c_rtos_mqx.ewp</path></project></workspace>
