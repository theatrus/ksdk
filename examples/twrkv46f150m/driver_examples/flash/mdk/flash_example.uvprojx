# Keil uVision project flash_example.uvprojx, settings and files
target flash_example Debug (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: flash_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV46F256VLL15, CLOCK_SETUP=4, TWR_KV46F150M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKV46F15/include;../../../../../platform/devices/MKV46F15/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../..;../../../../../platform/drivers/src/flash;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ../../../../../platform/devices/MKV46F15/linker/arm/MKV46F256xxx15_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV46F15/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKV46F15/startup/arm/: startup_MKV46F15.s
    ../../../../../platform/devices/MKV46F15/startup/: system_MKV46F15.c system_MKV46F15.h
    ../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group source
    ../: main.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashVerifySection.c
target flash_example Release (ARM-ADS)
  device: MKV46F256xxx15 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: flash_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV46F256VLL15, CLOCK_SETUP=4, TWR_KV46F150M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KV46F15/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
