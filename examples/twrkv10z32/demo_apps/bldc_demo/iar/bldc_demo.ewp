# IAR project bldc_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z32xxx7 Freescale MKV10Z32xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z32VLF7; TWR_KV10Z32; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MKV10Z7/include; ../../../../../platform/devices/MKV10Z7/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../MMCLIB; ../MMCLIB/Common; ../MMCLIB/GDFLIB; ../MMCLIB/GFLIB; ../MMCLIB/GMCLIB; ../MMCLIB/MLIB; ../project/peripherals; ../project; ../freemaster; ../../../../../platform/CMSIS/Include/device/MKV10Z7; ../../../../../platform/hal/src/sim/MKV10Z7; ../../..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bldc_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x200
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MKV10Z7/linker/iar/MKV10Z32xxx7_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV10Z7/debug/libksdk_platform.a; ../src/MMCLIB/CM0+_MMCLIB_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z32VLF7; TWR_KV10Z32; TOWER
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/KV10Z7/release/libksdk_platform.a; ../src/MMCLIB/CM0+_MMCLIB_IAR.a
  group startup
    ../../../../../platform/devices/MKV10Z7/startup/iar/: startup_MKV10Z7.s
    ../../../../../platform/devices/MKV10Z7/startup/: system_MKV10Z7.c
    ../../../../../platform/devices/: startup.c startup.h
  group source/project
    ../project/: main.c state_machine.c M1_StateMachine.c demonstration.c
  group source/project/peripherals
    ../project/peripherals/: MC33927.c peripherals_init.c
  group source/freemaster
    ../freemaster/: freemaster_appcmd.c freemaster_can.c freemaster_Kxx.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c
  group board
    ../freemaster/: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
