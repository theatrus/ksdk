<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>web_hvac_freertos</project><configuration>Release</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>web_hvac_freertos</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>web_hvac_freertos</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>web_hvac_freertos</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../lib/ksdk_freertos_lib/iar/K60D10/ksdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/web_hvac_freertos.ewp</path></project></workspace>
