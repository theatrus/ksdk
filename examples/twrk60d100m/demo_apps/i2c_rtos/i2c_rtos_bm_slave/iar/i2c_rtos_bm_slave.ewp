# IAR project i2c_rtos_bm_slave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER; FSL_RTOS_BM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MK60D10/include; ../../../../../../platform/devices/MK60D10/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_bm_slave.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MK60D10/linker/iar/MK60DN512xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/K60D10/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VMD10; TWR_K60D100M; TOWER; FSL_RTOS_BM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/K60D10/release/libksdk_platform.a
  group startup
    ../../../../../../platform/devices/MK60D10/startup/iar/: startup_MK60D10.s
    ../../../../../../platform/devices/MK60D10/startup/: system_MK60D10.c
    ../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: fsl_i2c_irq.c main_bm_slave.c task_slave.c i2c_rtos.h
