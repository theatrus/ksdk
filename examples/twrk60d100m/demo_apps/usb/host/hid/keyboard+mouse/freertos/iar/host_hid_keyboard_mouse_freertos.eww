<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbh_sdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>host_hid_keyboard_mouse_freertos</project><configuration>Debug</configuration></member><member><project>usbh_sdk_freertos_lib</project><configuration>Release</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>host_hid_keyboard_mouse_freertos</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_sdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>host_hid_keyboard_mouse_freertos</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_sdk_freertos_lib</project><configuration>Release</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>host_hid_keyboard_mouse_freertos</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/lib/freertos/iar/MK60D10/usbh_sdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_freertos_lib/iar/K60D10/ksdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/host_hid_keyboard_mouse_freertos.ewp</path></project></workspace>
