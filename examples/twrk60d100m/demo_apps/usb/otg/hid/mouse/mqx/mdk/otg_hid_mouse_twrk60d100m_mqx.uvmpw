<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../rtos/mqx/mqx/build/mdk/mqx_twrk60d100m/mqx_twrk60d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../rtos/mqx/mqx_stdlib/build/mdk/mqx_stdlib_twrk60d100m/mqx_stdlib_twrk60d100m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../usb/usb_core/otg/build/mdk/usbotg_sdk_twrk60d100m_mqx/usbotg_sdk_twrk60d100m_mqx.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_mqx_lib/mdk/K60D10/ksdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>otg_hid_mouse_twrk60d100m_mqx.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
