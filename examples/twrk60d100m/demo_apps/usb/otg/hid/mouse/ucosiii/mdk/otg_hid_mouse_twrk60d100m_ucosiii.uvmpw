<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/otg/build/mdk/usbotg_sdk_twrk60d100m_ucosiii/usbotg_sdk_twrk60d100m_ucosiii.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_ucosiii_lib/mdk/K60D10/ksdk_ucosiii_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>otg_hid_mouse_twrk60d100m_ucosiii.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
