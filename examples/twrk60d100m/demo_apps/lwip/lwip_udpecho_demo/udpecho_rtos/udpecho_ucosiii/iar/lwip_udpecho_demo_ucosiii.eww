<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>lwip_udpecho_demo_ucosiii</project><configuration>Release</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>lwip_udpecho_demo_ucosiii</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>lwip_udpecho_demo_ucosiii</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>lwip_udpecho_demo_ucosiii</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../lib/ksdk_ucosiii_lib/iar/K60D10/ksdk_ucosiii_lib.ewp</path></project><project><path>$WS_DIR$/lwip_udpecho_demo_ucosiii.ewp</path></project></workspace>
