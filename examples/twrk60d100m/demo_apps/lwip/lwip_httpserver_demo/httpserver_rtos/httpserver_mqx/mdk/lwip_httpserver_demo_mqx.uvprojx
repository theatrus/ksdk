# Keil uVision project lwip_httpserver_demo_mqx.uvprojx, settings and files
target lwip_httpserver_demo_mqx Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: lwip_httpserver_demo_mqx.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, FSL_RTOS_MQX, TWR_K60D100M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/config;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx_stdlib;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/nshell;../..;../../../../../../../../platform/osa/inc;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/devices;../../../../../../../../platform/devices/MK60D10/include;../../../../../../../../platform/devices/MK60D10/startup;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/system/inc;../../../../../../../../middleware/tcpip/lwip;../../../../../../../../middleware/tcpip/lwip/port;../../../../../../../../middleware/tcpip/lwip/port/arch;../../../../../../../../middleware/tcpip/lwip/src;../../../../../../../../middleware/tcpip/lwip/src/include;../../../../../../../../middleware/tcpip/lwip/src/include/ipv4;../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/ipv6;../../../../../../../../middleware/tcpip/lwip/src/include/ipv6/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/netif;../../../../../../../../middleware/tcpip/lwip/src/include/posix;../../../../../../../../middleware/tcpip/lwip/src/include;../../../../../../../../platform/utilities/inc;../../../../../../../../rtos/mqx/config/mcu/MK60D10;../../../../../../../../rtos/mqx/config/board/twrk60d100m;../..;../../../../../../../../platform/devices/MK60D10/include;../../../../../../../../platform/devices/MK60D10/startup;../../../../../../../../platform/system/inc;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/startup;../../../../../../../../rtos/mqx/config/common;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/devices/MK60D10/linker/arm/MK60DN512xxx10_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/K60D10/debug/libksdk_platform_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000"
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../: fsl_phy_driver.c main.c httpserver-netconn.h
  group board
    ../../: hardware_init.c
    ../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group lwip-port
    ../../../../../../../../middleware/tcpip/lwip/port/arch/: cc.h perf.h
    ../../../../../../../../middleware/tcpip/lwip/port/: ethernetif.c lwipopts.h sys_arch.c lwip_fsl_irq.c
    ../../../../../../../../platform/system/src/hwtimer/: fsl_hwtimer_pit_irq.c
  group lwip-src-api
    ../../../../../../../../middleware/tcpip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../../middleware/tcpip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c lwip_timers.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../../middleware/tcpip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-src-core-snmp
    ../../../../../../../../middleware/tcpip/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip-src-include-ipv4
    ../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip-src-include-lwip
    ../../../../../../../../middleware/tcpip/lwip/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h tcp_impl.h timers.h udp.h
  group lwip-src-include-netif
    ../../../../../../../../middleware/tcpip/lwip/src/include/netif/: etharp.h ppp_oe.h slipif.h
  group lwip-src-include-posix
    ../../../../../../../../middleware/tcpip/lwip/src/include/posix/: netdb.h
    ../../../../../../../../middleware/tcpip/lwip/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../../middleware/tcpip/lwip/src/netif/: etharp.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../../middleware/tcpip/lwip/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h pppdebug.h ppp_impl.h ppp_oe.c randm.c randm.h vj.c vj.h
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MK60D10/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk60d100m/: user_config.h
target lwip_httpserver_demo_mqx Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: as above
  output: lwip_httpserver_demo_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, FSL_RTOS_MQX, TWR_K60D100M, TOWER
  c misc: as above
  c include: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/config;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx_stdlib;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/nshell;../..;../../../../../../../../platform/osa/inc;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/devices;../../../../../../../../platform/devices/MK60D10/include;../../../../../../../../platform/devices/MK60D10/startup;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/system/inc;../../../../../../../../middleware/tcpip/lwip;../../../../../../../../middleware/tcpip/lwip/port;../../../../../../../../middleware/tcpip/lwip/port/arch;../../../../../../../../middleware/tcpip/lwip/src;../../../../../../../../middleware/tcpip/lwip/src/include;../../../../../../../../middleware/tcpip/lwip/src/include/ipv4;../../../../../../../../middleware/tcpip/lwip/src/include/ipv4/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/ipv6;../../../../../../../../middleware/tcpip/lwip/src/include/ipv6/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/lwip;../../../../../../../../middleware/tcpip/lwip/src/include/netif;../../../../../../../../middleware/tcpip/lwip/src/include/posix;../../../../../../../../middleware/tcpip/lwip/src/include;../../../../../../../../platform/utilities/inc;../../../../../../../../rtos/mqx/config/mcu/MK60D10;../../../../../../../../rtos/mqx/config/board/twrk60d100m;../..;../../../../../../../../platform/devices/MK60D10/include;../../../../../../../../platform/devices/MK60D10/startup;../../../../../../../../platform/system/inc;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/startup;../../../../../../../../rtos/mqx/config/common;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../..
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/K60D10/release/libksdk_platform_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x8000"
