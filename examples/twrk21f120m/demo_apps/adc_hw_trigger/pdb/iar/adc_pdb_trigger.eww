<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>adc_pdb_trigger</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>adc_pdb_trigger</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>adc_pdb_trigger</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>adc_pdb_trigger</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../lib/ksdk_platform_lib/iar/K21FA12/ksdk_platform_lib.ewp</path></project><project><path>$WS_DIR$/adc_pdb_trigger.ewp</path></project></workspace>
