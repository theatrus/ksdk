# IAR project i2c_rtos_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK21FN1M0AVMC12; FSL_RTOS_FREE_RTOS; TWR_K21F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/FreeRTOS/config/K21FA12/iar; ../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MK21FA12/include; ../../../../../../platform/devices/MK21FA12/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../..; ../../../../../../platform/drivers/src/i2c; ../../../../../../rtos/FreeRTOS/include; ../../../../../../rtos/FreeRTOS/src; ../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../rtos/FreeRTOS/config/K21FA12/iar
  ILINK.IlinkOutputFile: i2c_rtos_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MK21FA12/linker/iar/MK21FN1M0Axxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_freertos_lib/iar/K21FA12/debug/libksdk_platform_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK21FN1M0AVMC12; FSL_RTOS_FREE_RTOS; TWR_K21F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_freertos_lib/iar/K21FA12/release/libksdk_platform_freertos.a
  group free-rtos
    ../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../platform/devices/MK21FA12/startup/iar/: startup_MK21FA12.s
    ../../../../../../platform/devices/MK21FA12/startup/: system_MK21FA12.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: fsl_i2c_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
