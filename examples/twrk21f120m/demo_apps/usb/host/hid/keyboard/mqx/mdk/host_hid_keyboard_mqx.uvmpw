<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK21FA12/usbh_sdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_mqx_lib/mdk/K21FA12/ksdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../rtos/mqx/mqx/build/mdk/mqx_twrk21f120m/mqx_twrk21f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../rtos/mqx/mqx_stdlib/build/mdk/mqx_stdlib_twrk21f120m/mqx_stdlib_twrk21f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>host_hid_keyboard_mqx.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
