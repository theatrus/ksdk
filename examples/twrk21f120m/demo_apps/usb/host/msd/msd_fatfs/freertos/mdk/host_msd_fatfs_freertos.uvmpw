<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/host/lib/freertos/mdk/MK21FA12/usbh_sdk_freertos_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_freertos_lib/mdk/K21FA12/ksdk_freertos_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>host_msd_fatfs_freertos.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
