<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbotg_sdk_twrk21f120m_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>otg_hid_mouse_twrk21f120m_bm</project><configuration>Debug</configuration></member><member><project>usbotg_sdk_twrk21f120m_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>otg_hid_mouse_twrk21f120m_bm</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbotg_sdk_twrk21f120m_bm</project><configuration>Debug</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>otg_hid_mouse_twrk21f120m_bm</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbotg_sdk_twrk21f120m_bm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>otg_hid_mouse_twrk21f120m_bm</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/otg/build/iar/usbotg_sdk_twrk21f120m_bm/usbotg_sdk_twrk21f120m_bm.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_platform_lib/iar/K21FA12/ksdk_platform_lib.ewp</path></project><project><path>$WS_DIR$/otg_hid_mouse_twrk21f120m_bm.ewp</path></project></workspace>
