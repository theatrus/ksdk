# IAR project sai_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK21FN1M0AVMC12; TWR_K21F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK21FA12/include; ../../../../../platform/devices/MK21FA12/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ..; ..; ../../../../../platform/composite/inc; ../../../../../platform/drivers/src/edma; ../../../../../platform/drivers/src/sai; ../../../../../platform/drivers/src/i2c; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sai_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK21FA12/linker/iar/MK21FN1M0Axxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K21FA12/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK21FN1M0AVMC12; TWR_K21F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K21FA12/release/libksdk_platform.a
  group startup
    ../../../../../platform/devices/MK21FA12/startup/iar/: startup_MK21FA12.s
    ../../../../../platform/devices/MK21FA12/startup/: system_MK21FA12.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../: fsl_sgtl5000_driver.c fsl_sgtl5000_driver.h
  group soundcard
    ../../../../../platform/composite/src/soundcard/: fsl_soundcard.c
    ../../../../../platform/composite/inc/: fsl_soundcard.h
  group interrupt_handlers
    ../: fsl_edma_irq.c fsl_i2c_irq.c fsl_sai_irq.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
