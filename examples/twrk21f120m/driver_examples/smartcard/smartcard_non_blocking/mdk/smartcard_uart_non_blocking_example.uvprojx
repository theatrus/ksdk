# Keil uVision project smartcard_uart_non_blocking_example.uvprojx, settings and files
target smartcard_uart_non_blocking_example Debug (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: smartcard_uart_non_blocking_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK21FN1M0AVMC12, USING_EDMA, USING_NCN8025_INTERFACE, TWR_K21F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MK21FA12/include;../../../../../../platform/devices/MK21FA12/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../../../../../../platform/drivers/src/smartcard;../../../../../../platform/drivers/src/smartcard/interface;../../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../platform/devices/MK21FA12/linker/arm/MK21FN1M0Axxx12_flash.scf
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/K21FA12/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MK21FA12/startup/arm/: startup_MK21FA12.s
    ../../../../../../platform/devices/MK21FA12/startup/: system_MK21FA12.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../: fsl_smartcard_irq.c fsl_edma_irq.c main.c
    ../../../../../../platform/system/src/hwtimer/: fsl_hwtimer_pit_irq.c
  group board
    ../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target smartcard_uart_non_blocking_example Release (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale
  cpu: as above
  output: smartcard_uart_non_blocking_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK21FN1M0AVMC12, USING_EDMA, USING_NCN8025_INTERFACE, TWR_K21F120M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_platform_lib/mdk/K21FA12/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000"
