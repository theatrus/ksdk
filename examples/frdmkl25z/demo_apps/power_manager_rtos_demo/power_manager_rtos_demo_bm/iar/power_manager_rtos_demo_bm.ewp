# IAR project power_manager_rtos_demo_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; FSL_RTOS_BM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL25Z4/include; ../../../../../../platform/devices/MKL25Z4/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../platform/utilities/inc; ../../../..; ../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager_rtos_demo_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x0400; __heap_size__=0x0200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKL25Z4/linker/iar/MKL25Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KL25Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; FSL_RTOS_BM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KL25Z4/release/libksdk_platform.a
  group startup
    ../../../../../../platform/devices/MKL25Z4/startup/iar/: startup_MKL25Z4.s
    ../../../../../../platform/devices/MKL25Z4/startup/: system_MKL25Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: adc16_lpm_callback.c adc16_temperature.c adc16_temperature.h debug_console_lpm_callback.c fsl_adc_irq.c fsl_lptmr_irq.c fsl_rtc_irq.c fsl_uart_irq.c main.c lpm_rtos.h lptmr_setup.c lptmr_setup.h register_callback.c rtc_setup.c rtc_setup.h rtos_lpm_callback.c task_lpm.c task_lpm.h
