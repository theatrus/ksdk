# Keil uVision project i2c_rtos_freertos.uvprojx, settings and files
target i2c_rtos_freertos Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: i2c_rtos_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../rtos/FreeRTOS/config/KL25Z4/mdk;../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/devices;../../../../../../platform/devices/MKL25Z4/include;../../../../../../platform/devices/MKL25Z4/startup;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/system/inc;../../../../../../rtos/FreeRTOS/include;../../../../../../rtos/FreeRTOS/src;../../../../../../platform/utilities/inc;../../../..;../..;../../../../../../platform/drivers/src/i2c
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/KL25Z4/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../../platform/devices/MKL25Z4/linker/arm/MKL25Z128xxx4_flash.scf
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/KL25Z4/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x0400" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group free-rtos
    ../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../platform/devices/MKL25Z4/startup/arm/: startup_MKL25Z4.s
    ../../../../../../platform/devices/MKL25Z4/startup/: system_MKL25Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: fsl_i2c_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
target i2c_rtos_freertos Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  cpu: as above
  output: i2c_rtos_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, FRDM_KL25Z, FREEDOM, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../rtos/FreeRTOS/config/KL25Z4/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
  link misc: ../../../../../../lib/ksdk_freertos_lib/mdk/KL25Z4/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x0400" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
