# IAR project i2c_rtos_ucosii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; FSL_RTOS_UCOSII
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M0/Generic/IAR; ../../../../../../rtos/uCOSII/src/uC-CPU/ARM-Cortex-M0/IAR; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKL25Z4/include; ../../../../../../platform/devices/MKL25Z4/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../../../../rtos/uCOSII/src/config; ../../../../../../rtos/uCOSII/src/uCOS-II/Source; ../../../../../../rtos/uCOSII/src/uC-CPU; ../../../../../../rtos/uCOSII/src/uC-LIB; ../../../../../../platform/utilities/inc; ../../../..; ../..; ../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_ucosii.out
  ILINK.IlinkConfigDefines: __stack_size__=0x0400; __heap_size__=0x0200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKL25Z4/linker/iar/MKL25Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosii_lib/iar/KL25Z4/debug/libksdk_platform_ucosii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM; FSL_RTOS_UCOSII
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_ucosii_lib/iar/KL25Z4/release/libksdk_platform_ucosii.a
  group ucosii
    ../../../../../../rtos/uCOSII/src/uCOS-II/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../../../../../../rtos/uCOSII/src/config/: app_hooks.c
    ../../../../../../rtos/uCOSII/src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group startup
    ../../../../../../platform/devices/MKL25Z4/startup/iar/: startup_MKL25Z4.s
    ../../../../../../platform/devices/MKL25Z4/startup/: system_MKL25Z4.c
    ../../../../../../platform/devices/: startup.c startup.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../../: hardware_init.c
  group source
    ../../: fsl_i2c_irq.c main.c task_master.c task_slave.c task_sample.c i2c_rtos.h
