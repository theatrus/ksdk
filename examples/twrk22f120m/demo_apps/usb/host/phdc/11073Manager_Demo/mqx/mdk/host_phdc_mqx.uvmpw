<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK22F51212/usbh_sdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_mqx_lib/mdk/K22F51212/ksdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../rtos/mqx/mqx/build/mdk/mqx_twrk22f120m/mqx_twrk22f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../rtos/mqx/mqx_stdlib/build/mdk/mqx_stdlib_twrk22f120m/mqx_stdlib_twrk22f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>host_phdc_mqx.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
