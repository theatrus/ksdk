<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbh_sdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>host_audio_speaker_freertos</project><configuration>Debug</configuration></member><member><project>usbh_sdk_freertos_lib</project><configuration>Release</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>host_audio_speaker_freertos</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbh_sdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>host_audio_speaker_freertos</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbh_sdk_freertos_lib</project><configuration>Release</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>host_audio_speaker_freertos</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/host/lib/freertos/iar/MK22F51212/usbh_sdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_freertos_lib/iar/K22F51212/ksdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/host_audio_speaker_freertos.ewp</path></project></workspace>
