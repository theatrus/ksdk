# IAR project otg_hid_mouse_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VDC12; USBCFG_OTG; TWR_K22F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MK22F51212/include; ../../../../../../../../../platform/devices/MK22F51212/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MK22F51212; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MK22F51212; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../usb/usb_core/otg/sources/driver/khci; ../../../../../../../../../usb/usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../../../usb/usb_core/otg/include; ../../../../../../../../../usb/usb_core/otg/sources/otg; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/edma; ../../../../../../../../../platform/drivers/src/lpuart; ../../../../../../../../../platform/system/inc; ../..; ../../../../../../../../../platform/drivers/src/sai; ../../../../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: otg_hid_mouse_bm.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MK22F51212/linker/iar/MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/otg/lib/bm/iar/MK22F51212/debug/libusbotg_bm.a; ../../../../../../../../../lib/ksdk_platform_lib/iar/K22F51212/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VDC12; USBCFG_OTG; TWR_K22F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/otg/lib/bm/iar/MK22F51212/release/libusbotg_bm.a; ../../../../../../../../../lib/ksdk_platform_lib/iar/K22F51212/release/libksdk_platform.a
  group startup
    ../../../../../../../../../platform/devices/MK22F51212/startup/iar/: startup_MK22F51212.s
    ../../../../../../../../../platform/devices/MK22F51212/startup/: system_MK22F51212.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: dev_mouse.c dev_mouse.h dev_mouse_api.h host_mouse.c host_mouse.h host_mouse_api.h otg_mouse.c otg_mouse.h usb_descriptor.c usb_descriptor.h
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
