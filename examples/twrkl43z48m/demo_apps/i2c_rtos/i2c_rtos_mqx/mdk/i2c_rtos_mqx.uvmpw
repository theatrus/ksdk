<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../lib/ksdk_mqx_lib/mdk/KL43Z4/ksdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../rtos/mqx/nshell/build/mdk/nshell_twrkl43z48m/nshell_twrkl43z48m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../rtos/mqx/mqx_stdlib/build/mdk/mqx_stdlib_twrkl43z48m/mqx_stdlib_twrkl43z48m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../rtos/mqx/mqx/build/mdk/mqx_twrkl43z48m/mqx_twrkl43z48m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>i2c_rtos_mqx.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
