<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../../usb/usb_core/device/build/mdk/usbd_sdk_twrkl43z48m_bm/usbd_sdk_twrkl43z48m_bm.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../../../lib/ksdk_platform_lib/mdk/KL43Z4/ksdk_platform_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>dev_hid_audio_twrkl43z48m_bm.uvprojx</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
