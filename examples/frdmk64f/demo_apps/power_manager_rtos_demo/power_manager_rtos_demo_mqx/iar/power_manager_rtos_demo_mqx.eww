<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>nshell_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_frdmk64f</project><configuration>release</configuration></member><member><project>power_manager_rtos_demo_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>nshell_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>power_manager_rtos_demo_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>nshell_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_frdmk64f</project><configuration>release</configuration></member><member><project>power_manager_rtos_demo_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>nshell_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>power_manager_rtos_demo_mqx</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../lib/ksdk_mqx_lib/iar/K64F12/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/nshell/build/iar/nshell_frdmk64f/nshell_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_frdmk64f/mqx_stdlib_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../../../../rtos/mqx/mqx/build/iar/mqx_frdmk64f/mqx_frdmk64f.ewp</path></project><project><path>$WS_DIR$/power_manager_rtos_demo_mqx.ewp</path></project></workspace>
