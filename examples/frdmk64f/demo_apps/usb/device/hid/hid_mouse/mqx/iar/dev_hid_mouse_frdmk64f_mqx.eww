<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>usbd_sdk_frdmk64f_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_mouse_frdmk64f_mqx</project><configuration>Debug</configuration></member><member><project>mqx_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>usbd_sdk_frdmk64f_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>dev_hid_mouse_frdmk64f_mqx</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>usbd_sdk_frdmk64f_mqx</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>dev_hid_mouse_frdmk64f_mqx</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>mqx_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>usbd_sdk_frdmk64f_mqx</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>dev_hid_mouse_frdmk64f_mqx</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx/build/iar/mqx_frdmk64f/mqx_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../rtos/mqx/mqx_stdlib/build/iar/mqx_stdlib_frdmk64f/mqx_stdlib_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../usb/usb_core/device/build/iar/usbd_sdk_frdmk64f_mqx/usbd_sdk_frdmk64f_mqx.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$/dev_hid_mouse_frdmk64f_mqx.ewp</path></project></workspace>
