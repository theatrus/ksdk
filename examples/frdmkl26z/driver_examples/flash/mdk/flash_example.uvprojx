# Keil uVision project flash_example.uvprojx, settings and files
target flash_example Debug (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: flash_example.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL26Z128VLH4, FRDM_KL26Z, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../platform/osa/inc;../../../../../platform/utilities/inc;../../../../../platform/CMSIS/Include;../../../../../platform/devices;../../../../../platform/devices/MKL26Z4/include;../../../../../platform/devices/MKL26Z4/startup;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../../../platform/drivers/src/flash;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/include;../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source;../../..
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../platform/devices/MKL26Z4/linker/arm/MKL26Z128xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL26Z4/debug/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/devices/MKL26Z4/startup/arm/: startup_MKL26Z4.s
    ../../../../../platform/devices/MKL26Z4/startup/: system_MKL26Z4.c
    ../../../../../platform/devices/: startup.c startup.h
  group source
    ../: main.c
    ../../../../../platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c FlashCommandSequence.c FlashEraseSector.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashVerifySection.c
  group board
    ../: hardware_init.c
    ../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
target flash_example Release (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: flash_example.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL26Z128VLH4, FRDM_KL26Z, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL26Z4/release/libksdk_platform.lib 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
