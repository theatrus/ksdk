# IAR project host_hid_keyboard_mouse_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z128xxx4 Freescale MKL26Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MKL26Z128VLH4; CLOCK_SETUP=4; FRDM_KL26Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../../platform/osa/inc; ../../../../../../../../../rtos; ../../../../../../../../../platform/utilities/inc; ../../../../../../../../../platform/CMSIS/Include; ../../../../../../../../../platform/devices; ../../../../../../../../../platform/devices/MKL26Z4/include; ../../../../../../../../../platform/devices/MKL26Z4/startup; ../../../../../../..; ../../../../../../../../../usb/adapter/sources; ../../../../../../../../../usb/adapter/sources/sdk; ../../../../../../../../../usb/usb_core/device/include/MKL26Z4; ../../../../../../../../../usb/usb_core/device/include; ../../../../../../../../../usb/usb_core/device/sources/classes/audio; ../../../../../../../../../usb/usb_core/device/sources/classes/cdc; ../../../../../../../../../usb/usb_core/device/sources/classes/common; ../../../../../../../../../usb/usb_core/device/sources/classes/composite; ../../../../../../../../../usb/usb_core/device/sources/classes/hid; ../../../../../../../../../usb/usb_core/device/sources/classes/include; ../../../../../../../../../usb/usb_core/device/sources/classes/include/config; ../../../../../../../../../usb/usb_core/device/sources/classes/msd; ../../../../../../../../../usb/usb_core/device/sources/classes/phdc; ../../../../../../../../../usb/usb_core/device/sources/classes/video; ../../../../../../../../../usb/usb_core/device/sources/controller/khci; ../../../../../../../../../usb/usb_core/device/sources/controller; ../../../../../../../../../usb/usb_core/hal; ../../../../../../../../../usb/usb_core/host/include/MKL26Z4; ../../../../../../../../../usb/usb_core/host/include; ../../../../../../../../../usb/usb_core/host/sources/classes/audio; ../../../../../../../../../usb/usb_core/host/sources/classes/cdc; ../../../../../../../../../usb/usb_core/host/sources/classes/hid; ../../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../../usb/usb_core/host/sources/classes/phdc; ../../../../../../../../../usb/usb_core/host/sources/classes/printer; ../../../../../../../../../usb/usb_core/host/sources/controller/khci; ../../../../../../../../../usb/usb_core/host/sources/controller; ../../../../../../../../../usb/usb_core/include; ../../../../../../../../../platform/hal/inc; ../../../../../../../../../platform/drivers/inc; ../../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../../platform/drivers/src/pit; ../../../../../../../../../platform/drivers/src/dma; ../../../../../../../../../platform/system/inc; ../..; ../../../../../../../../../platform/drivers/src/uart; ../../../../../../../../../platform/drivers/src/i2c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_hid_keyboard_mouse_bm.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x0800; __heap_size__=0x2100
  ILINK.IlinkIcfFile: ../../../../../../../../../platform/devices/MKL26Z4/linker/iar/MKL26Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/bm/iar/MKL26Z4/debug/libusbh_bm.a; ../../../../../../../../../lib/ksdk_platform_lib/iar/KL26Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MKL26Z128VLH4; CLOCK_SETUP=4; FRDM_KL26Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../../usb/usb_core/host/lib/bm/iar/MKL26Z4/release/libusbh_bm.a; ../../../../../../../../../lib/ksdk_platform_lib/iar/KL26Z4/release/libksdk_platform.a
  group startup
    ../../../../../../../../../platform/devices/MKL26Z4/startup/iar/: startup_MKL26Z4.s
    ../../../../../../../../../platform/devices/MKL26Z4/startup/: system_MKL26Z4.c
    ../../../../../../../../../platform/devices/: startup.c startup.h
  group sources
    ../../: hidkeyboard.c hidkeyboard.h hidmouse.c hidmouse.h mouse_keyboard.c mouse_keyboard.h
    ../../../../../../../../../platform/system/src/hwtimer/: fsl_hwtimer_pit_irq.c
  group board
    ../../: hardware_init.c
    ../../../../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h board.c
  group utilities
    ../../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
