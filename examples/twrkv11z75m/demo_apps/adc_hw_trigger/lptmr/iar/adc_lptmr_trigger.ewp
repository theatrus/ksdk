# IAR project adc_lptmr_trigger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 Freescale MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKV11Z128VLH7; USE_DAC_OUT_AS_SOURCE; TWR_KV11Z75M; TWR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/devices; ../../../../../../platform/devices/MKV11Z7/include; ../../../../../../platform/devices/MKV11Z7/startup; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/system/inc; ../../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: adc_lptmr_trigger.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x200; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../platform/devices/MKV11Z7/linker/iar/MKV11Z128xxx7_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KV11Z7/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV11Z128VLH7; USE_DAC_OUT_AS_SOURCE; TWR_KV11Z75M; TWR
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/ksdk_platform_lib/iar/KV11Z7/release/libksdk_platform.a
  group startup
    ../../../../../../platform/devices/MKV11Z7/startup/iar/: startup_MKV11Z7.s
    ../../../../../../platform/devices/MKV11Z7/startup/: system_MKV11Z7.c
    ../../../../../../platform/devices/: startup.c startup.h
  group source
    ../../: dac_gen_wave.c main.c lptmr_trigger.c fsl_adc_irq.c
    ../../../../../../platform/system/src/hwtimer/: fsl_hwtimer_systick_irq.c
  group board
    ../../: hardware_init.c
    ../../../../: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
  group utilities
    ../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../platform/utilities/inc/: fsl_debug_console.h
