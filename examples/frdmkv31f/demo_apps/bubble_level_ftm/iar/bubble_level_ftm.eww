<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>bubble_level_ftm</project><configuration>Release</configuration></member><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>bubble_level_ftm</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_platform_lib</project><configuration>Release</configuration></member><member><project>bubble_level_ftm</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_platform_lib</project><configuration>Debug</configuration></member><member><project>bubble_level_ftm</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../lib/ksdk_platform_lib/iar/KV31F51212/ksdk_platform_lib.ewp</path></project><project><path>$WS_DIR$/bubble_level_ftm.ewp</path></project></workspace>
