# Keil uVision project usbd_sdk_ucosiii_lib.uvprojx, settings and files
target usbd_sdk_ucosiii_lib Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: libusbd_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK60DN512VMD10, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../rtos;../../../../../../../rtos/uCOSIII/src/config;../../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../adapter/sources;../../../../../../adapter/sources/sdk;../../../../../include;../../../../include;../../../../sources/classes/audio;../../../../sources/classes/cdc;../../../../sources/classes/common;../../../../sources/classes/composite;../../../../sources/classes/hid;../../../../sources/classes/include;../../../../sources/classes/include/config;../../../../sources/classes/msd;../../../../sources/classes/phdc;../../../../sources/classes/video;../../../../sources/controller;../../../../sources/controller/khci;../../../../sources/controller/ehci;../../../../../hal;../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../../platform/system/inc;../../../../../../../platform/hal/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/devices/MK60D10/include;../../../../../../../platform/devices/MK60D10/startup;../../../../../../../platform/devices/MK60D10;../../../../include/MK60D10
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group adapter
    ../../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter-sdk
    ../../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core-include
    ../../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core-device-include
    ../../../../include/: usb_device_stack_interface.h
    ../../../../include/MK60D10/: usb_device_config.h
  group usb_core-device-sources-class driver-include
    ../../../../sources/classes/include/: usb_class.h usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class_video.h
  group usb_core-device-sources-class driver-common
    ../../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core-device-sources-class driver-audio
    ../../../../sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core-device-sources-class driver-cdc
    ../../../../sources/classes/cdc/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h
  group usb_core-device-sources-class driver-composite
    ../../../../sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core-device-sources-class driver-hid
    ../../../../sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core-device-sources-class driver-msd
    ../../../../sources/classes/msd/: usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h
  group usb_core-device-sources-class driver-phdc
    ../../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core-device-sources-class driver-video
    ../../../../sources/classes/video/: usb_video.c usb_video.h
  group usb_core-device-sources-controller driver
    ../../../../sources/controller/: usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core-device-sources-controller driver-khci
    ../../../../sources/controller/khci/: device_khci_interface.c khci_dev.c khci_dev.h khci_dev_misc.h
  group usb_core-device-sources-bsp
    ../../../../sources/bsp/MK60D10/: usb_dev_bsp.c
target usbd_sdk_ucosiii_lib Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: as above
  output: libusbd_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: _DEBUG=0, CPU_MK60DN512VMD10, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
