# Keil uVision project usbd_sdk_twrk64f120m_ucosiii.uvproj, settings and files
target usbd_sdk_twrk64f120m_ucosiii Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: libusbd_ucosiii.lib (library)
  BeforeMake: ../../../../../usb_core/device/build/bat/usbd_twrk64f120m.bat ../../../../.. ../../../../../output/twrk64f120m.mdk/debug/usbd/sdk mdk sdk
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../rtos;../../../../../../rtos/uCOSIII/src/config;../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../adapter/sources;../../../../../adapter/sources/sdk;../../../../include;../../../include;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/common;../../../sources/classes/composite;../../../sources/classes/hid;../../../sources/classes/include;../../../sources/classes/include/config;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/khci;../../../../hal;../../../../../../platform/osa/inc;../../../../../../platform/utilities/inc;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/system/inc;../../../../../../platform/hal/inc;../../../../../../platform/startup/MK64F12;../../../../../../platform/CMSIS/Include/device/MK64F12;../../../include/twrk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter-sdk
    ../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core-include
    ../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core-device-include
    ../../../include/: usb_device_stack_interface.h
    ../../../include/twrk64f120m/: usb_device_config.h
  group usb_core-device-sources-class driver-include
    ../../../sources/classes/include/: usb_class.h usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h
  group usb_core-device-sources-class driver-common
    ../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core-device-sources-class driver-audio
    ../../../sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core-device-sources-class driver-cdc
    ../../../sources/classes/cdc/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h
  group usb_core-device-sources-class driver-composite
    ../../../sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core-device-sources-class driver-hid
    ../../../sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core-device-sources-class driver-msd
    ../../../sources/classes/msd/: usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h
  group usb_core-device-sources-class driver-phdc
    ../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core-device-sources-controller driver
    ../../../sources/controller/: khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core-device-sources-controller driver-khci
    ../../../sources/controller/khci/: khci_dev.c khci_dev.h khci_dev_misc.h
  group usb_core-device-sources-bsp
    ../../../sources/bsp/twrk64f120m/: usb_dev_bsp.c
target usbd_sdk_twrk64f120m_ucosiii Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: libusbd_ucosiii.lib (library)
  BeforeMake: as above
  AfterMake: as above
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
