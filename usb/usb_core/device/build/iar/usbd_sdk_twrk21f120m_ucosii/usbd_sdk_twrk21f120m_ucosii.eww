<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbd_sdk_twrk21f120m_ucosii.ewp</path>
  </project>
</workspace>
