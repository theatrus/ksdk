<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbd_sdk_twrkl43z48m_ucosiii.ewp</path>
  </project>
</workspace>
