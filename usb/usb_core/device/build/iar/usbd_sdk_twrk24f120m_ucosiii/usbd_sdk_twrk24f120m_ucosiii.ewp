# IAR project usbd_sdk_twrk24f120m_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 Freescale MK24FN256xxx12
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; IAR; FSL_RTOS_UCOSIII; TWR_K24F120M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../../../../rtos; ../../../../../../rtos/uCOSIII/src/config; ../../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../adapter/sources; ../../../../../adapter/sources/sdk; ../../../../include; ../../../include; ../../../sources/classes/audio; ../../../sources/classes/cdc; ../../../sources/classes/common; ../../../sources/classes/composite; ../../../sources/classes/hid; ../../../sources/classes/include; ../../../sources/classes/include/config; ../../../sources/classes/msd; ../../../sources/classes/phdc; ../../../sources/controller; ../../../sources/controller/khci; ../../../../hal; ../../../../../../platform/osa/inc; ../../../../../../platform/utilities/inc; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/system/inc; ../../../../../../platform/hal/inc; ../../../../../../platform/startup/MK24F25612; ../../../../../../platform/CMSIS/Include/device/MK24F25612; ../../../include/twrk24f120m
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; IAR; FSL_RTOS_UCOSIII; TWR_K24F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter/sdk
    ../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core/device/include
    ../../../include/: usb_device_stack_interface.h
    ../../../include/twrk24f120m/: usb_device_config.h
  group usb_core/device/sources/class driver/include
    ../../../sources/classes/include/: usb_class.h usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h
  group usb_core/device/sources/class driver/common
    ../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/audio
    ../../../sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core/device/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_cdc.c usb_cdc.h usb_cdc_pstn.c usb_cdc_pstn.h
  group usb_core/device/sources/class driver/composite
    ../../../sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core/device/sources/class driver/hid
    ../../../sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core/device/sources/class driver/msd
    ../../../sources/classes/msd/: usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h
  group usb_core/device/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core/device/sources/controller driver
    ../../../sources/controller/: khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/khci
    ../../../sources/controller/khci/: khci_dev.c khci_dev.h khci_dev_misc.h
  group usb_core/device/sources/bsp
    ../../../sources/bsp/twrk24f120m/: usb_dev_bsp.c
