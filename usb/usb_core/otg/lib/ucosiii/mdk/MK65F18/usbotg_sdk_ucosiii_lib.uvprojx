# Keil uVision project usbotg_sdk_ucosiii_lib.uvprojx, settings and files
target usbotg_sdk_ucosiii_lib Debug (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  output: libusbotg_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK65FN2M0VMI18, FSL_RTOS_UCOSIII, USBCFG_OTG
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../rtos;../../../../../../../rtos/uCOSIII/src/config;../../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/hal/inc;../../../../../../../platform/system/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/drivers/src/gpio;../../../../../../../platform/drivers/src/uart;../../../../../../../platform/drivers/src/i2c;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../adapter/sources;../../../../../../adapter/sources/sdk;../../../../../include;../../../../../hal;../../../../../host/include;../../../../../host/sources/classes/audio;../../../../../host/sources/classes/cdc;../../../../../host/sources/classes/common;../../../../../host/sources/classes/hid;../../../../../host/sources/classes/hub;../../../../../host/sources/classes/msd;../../../../../host/sources/classes/phdc;../../../../../host/sources/controller;../../../../../host/sources/controller/khci;../../../../../device/include;../../../../../device/sources/classes/audio;../../../../../device/sources/classes/cdc;../../../../../device/sources/classes/common;../../../../../device/sources/classes/composite;../../../../../device/sources/classes/hid;../../../../../device/sources/classes/include;../../../../../device/sources/classes/include/config;../../../../../device/sources/classes/msd;../../../../../device/sources/classes/phdc;../../../../../device/sources/classes/video;../../../../../device/sources/controller;../../../../../device/sources/controller/khci;../../../../include;../../../../sources/otg;../../../../sources/driver;../../../../sources/driver/khci;../../../../sources/driver/max3353;../../../../sources/driver/max3353/sdk;../../../../../../../platform/devices/MK65F18/include;../../../../../../../platform/devices/MK65F18/startup;../../../../../../../platform/devices/MK65F18;../../../../../host/include/MK65F18;../../../../../device/include/MK65F18;../../../../include/MK65F18;../../../../../../../examples/twrk65f180m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group adapter
    ../../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter-sdk
    ../../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core-include
    ../../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core-device-include
    ../../../../../device/include/: usb_device_stack_interface.h
    ../../../../../device/include/MK65F18/: usb_device_config.h
  group usb_core-device-sources-class driver-include
    ../../../../../device/sources/classes/include/: usb_class.h usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h
  group usb_core-device-sources-class driver-common
    ../../../../../device/sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core-device-sources-class driver-audio
    ../../../../../device/sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core-device-sources-class driver-cdc
    ../../../../../device/sources/classes/cdc/: usb_cdc.c usb_cdc.h
  group usb_core-device-sources-class driver-composite
    ../../../../../device/sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core-device-sources-class driver-hid
    ../../../../../device/sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core-device-sources-class driver-msd
    ../../../../../device/sources/classes/msd/: usb_msc.c usb_msc.h usb_msc_scsi.c usb_msc_scsi.h
  group usb_core-device-sources-class driver-phdc
    ../../../../../device/sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core-device-sources-class driver-video
    ../../../../../device/sources/classes/video/: usb_video.c usb_video.h
  group usb_core-device-sources-controller driver
    ../../../../../device/sources/controller/: usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core-device-sources-controller driver-khci
    ../../../../../device/sources/controller/khci/: device_khci_interface.c khci_dev.c khci_dev.h khci_dev_misc.h
  group usb_core-device-sources-controller driver-ehci
    ../../../../../device/sources/controller/ehci/: ehci_dev_main.c ehci_dev_main.h device_ehci_interface.c ehci_usbprv.h
  group usb_core-host-sources-class driver-common
    ../../../../../host/sources/classes/common/: usb_classes.c
  group usb_core-host-sources-class driver-audio
    ../../../../../host/sources/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group usb_core-host-sources-class driver-cdc
    ../../../../../host/sources/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group usb_core-host-sources-class driver-hid
    ../../../../../host/sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core-host-sources-class driver-hub
    ../../../../../host/sources/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group usb_core-host-sources-class driver-msd
    ../../../../../host/sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core-host-sources-class driver-phdc
    ../../../../../host/sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core-host-sources-controller driver
    ../../../../../host/sources/controller/: usb_host.c usb_host.h usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h
  group usb_core-host-sources-controller driver-khci
    ../../../../../host/sources/controller/khci/: host_khci_interface.c khci.c khci.h khci_prv.h
  group usb_core-host-sources-controller driver-ehci
    ../../../../../host/sources/controller/ehci/: ehci_host.c ehci_prv.h host_ehci_interface.c
  group usb_core-otg-include
    ../../../../include/: usb_otg_dev_api.h usb_otg_host_api.h usb_otg_main.h
    ../../../../include/MK65F18/: usb_otg_config.h
  group usb_core-otg-sources-driver-khci
    ../../../../sources/driver/khci/: usb_otg_khci.c usb_otg_khci.h
  group usb_core-otg-sources-driver
    ../../../../sources/driver/: usb_otg.c usb_otg.h
    ../../../../sources/driver/max3353/: max3353_interface.c
  group usb_core-otg-sources-driver-max3353
    ../../../../sources/driver/max3353/sdk/: usb_otg_max3353.c
    ../../../../sources/driver/max3353/: usb_otg_max3353.h
  group usb_core-otg-sources-otg
    ../../../../sources/otg/: usb_otg_main.c usb_otg_private.h usb_otg_sm.h usb_otg_sm_a.c usb_otg_sm_b.c usb_otg_sm_main.c
  group usb_core-device-sources-bsp
    ../../../../../device/sources/bsp/MK65F18/: usb_dev_bsp.c
  group usb_core-host-include
    ../../../../../host/include/MK65F18/: usb_host_config.h
  group usb_core-host-sources-bsp
    ../../../../../host/sources/bsp/MK65F18/: usb_host_bsp.c
  group usb_core-otg-sources-bsp
    ../../../../sources/bsp/MK65F18/: usb_otg_bsp.c
  group board
    ../../../../../../../examples/twrk65f180m/: board.h pin_mux.c pin_mux.h
target usbotg_sdk_ucosiii_lib Release (ARM-ADS)
  device: MK65FN2M0xxx18 Freescale
  output: libusbotg_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: _DEBUG=0, CPU_MK65FN2M0VMI18, FSL_RTOS_UCOSIII, USBCFG_OTG
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
