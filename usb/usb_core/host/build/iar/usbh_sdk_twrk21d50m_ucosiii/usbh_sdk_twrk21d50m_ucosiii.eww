<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbh_sdk_twrk21d50m_ucosiii.ewp</path>
  </project>
</workspace>
