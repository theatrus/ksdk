<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbh_sdk_frdmk64f_mqx.ewp</path>
  </project>
</workspace>
