# Keil uVision project usbh_sdk_ucosiii_lib.uvprojx, settings and files
target usbh_sdk_ucosiii_lib Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: libusbh_ucosiii.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK60DN512VMD10, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66
  c include: ../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../rtos;../../../../../../../rtos/uCOSIII/src/config;../../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../../platform/osa/inc;../../../../../../../platform/utilities/inc;../../../../../../../platform/hal/inc;../../../../../../../platform/system/inc;../../../../../../../platform/drivers/inc;../../../../../../../platform/drivers/src/gpio;../../../../../../../platform/drivers/src/uart;../../../../../../../platform/drivers/src/i2c;../../../../../../../platform/CMSIS/Include;../../../../../../../platform/devices;../../../../../../adapter/sources;../../../../../../adapter/sources/sdk;../../../../../include;../../../../../hal;../../../../include;../../../../sources/classes/audio;../../../../sources/classes/cdc;../../../../sources/classes/common;../../../../sources/classes/hid;../../../../sources/classes/hub;../../../../sources/classes/msd;../../../../sources/classes/phdc;../../../../sources/controller;../../../../sources/controller/khci;../../../../sources/controller/ehci;../../../../../../../platform/devices/MK60D10/include;../../../../../../../platform/devices/MK60D10/startup;../../../../../../../platform/devices/MK60D10;../../../../include/MK60D10;../../../../../../../examples/twrk60d100m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group adapter
    ../../../../../../adapter/sources/: adapter.h adapter_types.h
  group adapter-sdk
    ../../../../../../adapter/sources/sdk/: adapter_cfg.h adapter_sdk.c adapter_sdk.h
  group usb_core-include
    ../../../../../include/: compiler.h types.h usb.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
  group usb_core-host-include
    ../../../../include/: usb_host_stack_interface.h
    ../../../../include/MK60D10/: usb_host_config.h
  group usb_core-host-sources-class driver-common
    ../../../../sources/classes/common/: usb_classes.c
  group usb_core-host-sources-class driver-audio
    ../../../../sources/classes/audio/: usb_host_audio.c usb_host_audio.h usb_host_audio_intf.c
  group usb_core-host-sources-class driver-cdc
    ../../../../sources/classes/cdc/: usb_host_cdc.c usb_host_cdc.h usb_host_cdc_intf.c
  group usb_core-host-sources-class driver-hid
    ../../../../sources/classes/hid/: usb_host_hid.c usb_host_hid.h
  group usb_core-host-sources-class driver-hub
    ../../../../sources/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group usb_core-host-sources-class driver-msd
    ../../../../sources/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group usb_core-host-sources-class driver-phdc
    ../../../../sources/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group usb_core-host-sources-controller driver
    ../../../../sources/controller/: usb_host.c usb_host.h usb_host_ch9.c usb_host_ch9.h usb_host_common.c usb_host_common.h usb_host_dev_mng.c usb_host_dev_mng.h
  group usb_core-host-sources-controller driver-khci
    ../../../../sources/controller/khci/: host_khci_interface.c khci.c khci.h khci_prv.h
  group usb_core-host-sources-bsp
    ../../../../sources/bsp/MK60D10/: usb_host_bsp.c
target usbh_sdk_ucosiii_lib Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.1.0
  cpu: as above
  output: libusbh_ucosiii.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: _DEBUG=0, CPU_MK60DN512VMD10, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
--diag_suppress=66
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
