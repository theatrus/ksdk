<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/usbh_sdk_mqx_lib.ewp</path>
  </project>
</workspace>
