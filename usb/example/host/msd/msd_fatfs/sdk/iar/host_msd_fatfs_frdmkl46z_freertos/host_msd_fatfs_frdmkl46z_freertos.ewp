# IAR project host_msd_fatfs_frdmkl46z_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLL4; IAR; FRDM_KL46Z48M; FREEDOM; CLOCK_SETUP=4; FSL_RTOS_FREE_RTOS; USB_DISK_ENABLE=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/FreeRTOS/config/KL46Z4/iar; ../../../../../../../../rtos/FreeRTOS/port/iar; ../../../../../../../../platform/osa/inc; ../../../../../../../../rtos; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MKL46Z4; ../../../../../../../../boards/frdmkl46z; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../../../device/audio/generator; ../../../../../../device/audio/speaker; ../../../../../../device/cdc/virtual_com; ../../../../../../device/composite/hid_audio; ../../../../../../device/composite/msd_cdc; ../../../../../../device/hid/hid_keyboard; ../../../../../../device/hid/hid_mouse; ../../../../../../device/msd; ../../../../../../device/phdc/weighscale; ../../../../../audio/speaker; ../../../../../cdc/cdc_serial; ../../../../../cdc/cdc_serial/sdk/serial_bsp; ../../../../../hid/keyboard; ../../../../../hid/keyboard+mouse; ../../../../../hid/mouse; ../../../../msd_cmd; ../../../../../phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/frdmkl46z; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/frdmkl46z; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../platform/drivers/src/pit; ../../../../../../../../platform/drivers/src/dma; ../../../../../../../../platform/system/inc; ../../../../../../../../rtos/FreeRTOS/include; ../../../../../../../../rtos/FreeRTOS/src; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/hal; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/drivers/src/sai; ../../../../../../../../platform/drivers/src/edma; ../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../filesystem/fatfs; ../../../../../../../../filesystem/fatfs/fsl_usb_disk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../../rtos/FreeRTOS/config/KL46Z4/iar
  ILINK.IlinkOutputFile: host_msd_fatfs_freertos.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x1000; __heap_size__=0x4000
  ILINK.IlinkIcfFile: ../../../../../../../../platform/linker/MKL46Z4/iar/MKL46Z256xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmkl46z_freertos/debug/libusbh_freertos.a; ../../../../../../../../lib/ksdk_freertos_lib/iar/KL46Z4/debug/libksdk_platform_freertos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL46Z256VLL4; IAR; FRDM_KL46Z48M; FREEDOM; CLOCK_SETUP=4; FSL_RTOS_FREE_RTOS; USB_DISK_ENABLE=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../usb_core/host/build/iar/usbh_sdk_frdmkl46z_freertos/release/libusbh_freertos.a; ../../../../../../../../lib/ksdk_freertos_lib/iar/KL46Z4/release/libksdk_platform_freertos.a
  group free-rtos
    ../../../../../../../../rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
    ../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group startup
    ../../../../../../../../platform/startup/MKL46Z4/iar/: startup_MKL46Z4.s
    ../../../../../../../../platform/startup/MKL46Z4/: system_MKL46Z4.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/frdmkl46z/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: main.c
    ../../: msd_fat_demo.c
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources/fatfs
    ../../../../../../../../filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources/fatfs/option
    ../../../../../../../../filesystem/fatfs/option/: unicode.c
