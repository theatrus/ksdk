# Keil uVision project host_msd_fatfs_twrk22f120m_freertos.uvproj, settings and files
target host_msd_fatfs_twrk22f120m_freertos Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: host_msd_fatfs_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_FREE_RTOS, USB_DISK_ENABLE=1
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../../rtos/FreeRTOS/config/K22F51212/mdk;../../../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../../../platform/osa/inc;../../../../../../../../rtos;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK22F51212;../../../../../../../../boards/twrk22f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../audio/speaker;../../../../../cdc/cdc_serial;../../../../../cdc/cdc_serial/sdk/serial_bsp;../../../../../hid/keyboard;../../../../../hid/keyboard+mouse;../../../../../hid/mouse;../../../../msd_cmd;../../../../../phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/twrk22f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk22f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/drivers/src/gpio;../../../../../../../../platform/drivers/src/pit;../../../../../../../../platform/drivers/src/edma;../../../../../../../../platform/drivers/src/lpuart;../../../../../../../../platform/system/inc;../../../../../../../../rtos/FreeRTOS/include;../../../../../../../../rtos/FreeRTOS/src;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/hal;../../../../../../../../platform/drivers/src/sai;../../../../../../../../platform/drivers/src/i2c;../../../../../../../../filesystem/fatfs;../../../../../../../../filesystem/fatfs/fsl_usb_disk
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../rtos/FreeRTOS/config/K22F51212/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/linker/MK22F51212/arm/MK22FN512xxx12_flash.scf
  link misc: ../../../../../../../usb_core/host/build/mdk/usbh_sdk_twrk22f120m_freertos/debug/libusbh_freertos.lib 
../../../../../../../../lib/ksdk_freertos_lib/mdk/K22F51212/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
  group free-rtos
    ../../../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../../../../platform/startup/MK22F51212/: system_MK22F51212.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group board
    ../../../../../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: main.c
    ../../: msd_fat_demo.c
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources:fatfs
    ../../../../../../../../filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources:fatfs:option
    ../../../../../../../../filesystem/fatfs/option/: unicode.c
target host_msd_fatfs_twrk22f120m_freertos Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: host_msd_fatfs_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_FREE_RTOS, USB_DISK_ENABLE=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../rtos/FreeRTOS/config/K22F51212/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../usb_core/host/build/mdk/usbh_sdk_twrk22f120m_freertos/release/libusbh_freertos.lib 
../../../../../../../../lib/ksdk_freertos_lib/mdk/K22F51212/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
