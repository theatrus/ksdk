# Keil uVision project host_msd_fatfs_twrk60d100m_mqx.uvproj, settings and files
target host_msd_fatfs_twrk60d100m_mqx Debug (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: host_msd_fatfs_mqx.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK60DN512VMD10, KEIL, TWR_K60D100M, TOWER, CLOCK_SETUP=4, FSL_RTOS_MQX, USB_DISK_ENABLE=1
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/config;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx_stdlib;../../../../../../../../platform/osa/inc;../../../../../../../../rtos;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK60D10;../../../../../../../../boards/twrk60d100m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../audio/speaker;../../../../../cdc/cdc_serial;../../../../../cdc/cdc_serial/sdk/serial_bsp;../../../../../hid/keyboard;../../../../../hid/keyboard+mouse;../../../../../hid/mouse;../../../../msd_cmd;../../../../../phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/twrk60d100m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk60d100m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/drivers/src/gpio;../../../../../../../../platform/drivers/src/pit;../../../../../../../../platform/drivers/src/edma;../../../../../../../../platform/system/inc;../../../../../../../../rtos/mqx/config/mcu/mk60d100m;../../../../../../../../rtos/mqx/config/board/twrk60d100m;../../../../../../../../boards/common/phyksz8041;../../../../../../../../platform/startup/MK60D10;../../../../../../../../platform/system/inc;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/startup;../../../../../../../../rtos/mqx/config/common;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/hal;../../../../../../../../platform/drivers/src/sai;../../../../../../../../platform/drivers/src/i2c;../../../../../../../../filesystem/fatfs;../../../../../../../../filesystem/fatfs/fsl_usb_disk
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/linker/MK60D10/arm/MK60DN512xxx10_flash.scf
  link misc: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../usb_core/host/build/mdk/usbh_sdk_twrk60d100m_mqx/debug/libusbh_mqx.lib 
../../../../../../../../lib/ksdk_mqx_lib/mdk/K60D10/debug/libksdk_platform_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../../../../rtos/mqx/config/common/: maximum_config.h small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/mk60d100m/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk60d100m/: user_config.h
  group board
    ../../../../../../../../boards/twrk60d100m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: main.c
    ../../: msd_fat_demo.c
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/: msd_diskio.h
    ../../../../../../../../filesystem/fatfs/fsl_usb_disk/src/: msd_diskio.c
  group sources:fatfs
    ../../../../../../../../filesystem/fatfs/: diskio.c diskio.h ffconf.h ff.c ff.h
  group sources:fatfs:option
    ../../../../../../../../filesystem/fatfs/option/: unicode.c
target host_msd_fatfs_twrk60d100m_mqx Release (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.2
  cpu: as above
  output: host_msd_fatfs_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK60DN512VMD10, KEIL, TWR_K60D100M, TOWER, CLOCK_SETUP=4, FSL_RTOS_MQX, USB_DISK_ENABLE=1
  c misc: as above
  c include: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/config;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx;../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx_stdlib;../../../../../../../../platform/osa/inc;../../../../../../../../rtos;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK60D10;../../../../../../../../boards/twrk60d100m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../../../device/audio/generator;../../../../../../device/audio/speaker;../../../../../../device/cdc/virtual_com;../../../../../../device/composite/hid_audio;../../../../../../device/composite/msd_cdc;../../../../../../device/hid/hid_keyboard;../../../../../../device/hid/hid_mouse;../../../../../../device/msd;../../../../../../device/phdc/weighscale;../../../../../audio/speaker;../../../../../cdc/cdc_serial;../../../../../cdc/cdc_serial/sdk/serial_bsp;../../../../../hid/keyboard;../../../../../hid/keyboard+mouse;../../../../../hid/mouse;../../../../msd_cmd;../../../../../phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/twrk60d100m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk60d100m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/drivers/src/gpio;../../../../../../../../platform/drivers/src/pit;../../../../../../../../platform/drivers/src/edma;../../../../../../../../platform/system/inc;../../../../../../../../rtos/mqx/config/mcu/mk60d100m;../../../../../../../../rtos/mqx/config/board/twrk60d100m;../../../../../../../../boards/common/phyksz8041;../../../../../../../../platform/startup/MK60D10;../../../../../../../../platform/system/inc;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/startup;../../../../../../../../rtos/mqx/config/common;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/hal;../../../../../../../../platform/drivers/src/sai;../../../../../../../../platform/drivers/src/i2c;../../../../../../../../filesystem/fatfs;../../../../../../../../filesystem/fatfs/fsl_usb_disk
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../usb_core/host/build/mdk/usbh_sdk_twrk60d100m_mqx/release/libusbh_mqx.lib 
../../../../../../../../lib/ksdk_mqx_lib/mdk/K60D10/release/libksdk_platform_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk60d100m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
