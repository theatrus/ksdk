<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbd_sdk_twrk64f120m_ucosiii</project><configuration>Debug</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>dev_audio_generator_twrk64f120m_ucosiii</project><configuration>Debug</configuration></member><member><project>usbd_sdk_twrk64f120m_ucosiii</project><configuration>Release</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>dev_audio_generator_twrk64f120m_ucosiii</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbd_sdk_twrk64f120m_ucosiii</project><configuration>Debug</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Debug</configuration></member><member><project>dev_audio_generator_twrk64f120m_ucosiii</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbd_sdk_twrk64f120m_ucosiii</project><configuration>Release</configuration></member><member><project>ksdk_ucosiii_lib</project><configuration>Release</configuration></member><member><project>dev_audio_generator_twrk64f120m_ucosiii</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk64f120m_ucosiii/usbd_sdk_twrk64f120m_ucosiii.ewp</path></project><project><path>$WS_DIR$/../../../../../../../../lib/ksdk_ucosiii_lib/iar/K64F12/ksdk_ucosiii_lib.ewp</path></project><project><path>$WS_DIR$/dev_audio_generator_twrk64f120m_ucosiii.ewp</path></project></workspace>
