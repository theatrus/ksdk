# IAR project dev_audio_speaker_twrk60d100m_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VMD10; IAR; TWR_K60D100M; TOWER; CLOCK_SETUP=4; FSL_RTOS_MQX
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug/mqx_stdlib; ../../../../../../../../platform/osa/inc; ../../../../../../../../rtos; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK60D10; ../../../../../../../../boards/twrk60d100m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../generator; ../../..; ../../../../../cdc/virtual_com; ../../../../../composite/hid_audio; ../../../../../composite/msd_cdc; ../../../../../hid/hid_keyboard; ../../../../../hid/hid_mouse; ../../../../../msd; ../../../../../phdc/weighscale; ../../../../../../host/audio/speaker; ../../../../../../host/cdc/cdc_serial; ../../../../../../host/cdc/cdc_serial/sdk/serial_bsp; ../../../../../../host/hid/keyboard; ../../../../../../host/hid/keyboard+mouse; ../../../../../../host/hid/mouse; ../../../../../../host/msd/msd_cmd; ../../../../../../host/phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/twrk60d100m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/twrk60d100m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../platform/drivers/src/pit; ../../../../../../../../platform/drivers/src/edma; ../../../../../../../../platform/system/inc; ../../../../../../../../rtos/mqx/config/mcu/mk60d100m; ../../../../../../../../rtos/mqx/config/board/twrk60d100m; ../../../../../../../../boards/common/phyksz8041; ../../../../../../../../platform/startup/MK60D10; ../../../../../../../../platform/system/inc; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/startup; ../../../../../../../../rtos/mqx/config/common; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/src/sai; ../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../platform/composite/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dev_audio_speaker_mqx.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x4000; __heap_size__=0x8000
  ILINK.IlinkIcfFile: ../../../../../../../../platform/linker/MK60D10/iar/MK60DN512xxx10_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk60d100m_mqx/debug/libusbd_mqx.a; ../../../../../../../../lib/ksdk_mqx_lib/iar/K60D10/debug/libksdk_platform_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VMD10; IAR; TWR_K60D100M; TOWER; CLOCK_SETUP=4; FSL_RTOS_MQX
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release/mqx_stdlib; ../../../../../../../../platform/osa/inc; ../../../../../../../../rtos; ../../../../../../../../platform/utilities/inc; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/startup/MK60D10; ../../../../../../../../boards/twrk60d100m; ../../../../../../../adapter/sources; ../../../../../../../adapter/sources/sdk; ../../../../generator; ../../..; ../../../../../cdc/virtual_com; ../../../../../composite/hid_audio; ../../../../../composite/msd_cdc; ../../../../../hid/hid_keyboard; ../../../../../hid/hid_mouse; ../../../../../msd; ../../../../../phdc/weighscale; ../../../../../../host/audio/speaker; ../../../../../../host/cdc/cdc_serial; ../../../../../../host/cdc/cdc_serial/sdk/serial_bsp; ../../../../../../host/hid/keyboard; ../../../../../../host/hid/keyboard+mouse; ../../../../../../host/hid/mouse; ../../../../../../host/msd/msd_cmd; ../../../../../../host/phdc/11073Manager_Demo; ../../../../../../otg/hid/mouse; ../../../../../../../usb_core/device/include/twrk60d100m; ../../../../../../../usb_core/device/include; ../../../../../../../usb_core/device/sources/classes/audio; ../../../../../../../usb_core/device/sources/classes/cdc; ../../../../../../../usb_core/device/sources/classes/common; ../../../../../../../usb_core/device/sources/classes/composite; ../../../../../../../usb_core/device/sources/classes/hid; ../../../../../../../usb_core/device/sources/classes/include; ../../../../../../../usb_core/device/sources/classes/msd; ../../../../../../../usb_core/device/sources/classes/phdc; ../../../../../../../usb_core/device/sources/controller/khci; ../../../../../../../usb_core/device/sources/controller; ../../../../../../../usb_core/hal; ../../../../../../../usb_core/host/include/twrk60d100m; ../../../../../../../usb_core/host/include; ../../../../../../../usb_core/host/sources/classes/audio; ../../../../../../../usb_core/host/sources/classes/cdc; ../../../../../../../usb_core/host/sources/classes/hid; ../../../../../../../usb_core/host/sources/classes/hub; ../../../../../../../usb_core/host/sources/classes/msd; ../../../../../../../usb_core/host/sources/classes/phdc; ../../../../../../../usb_core/host/sources/classes/printer; ../../../../../../../usb_core/host/sources/controller/khci; ../../../../../../../usb_core/host/sources/controller; ../../../../../../../usb_core/include; ../../../../../../../usb_core/otg/sources/driver/khci; ../../../../../../../usb_core/otg/sources/driver/max3353/sdk; ../../../../../../../usb_core/otg/sources/include; ../../../../../../../usb_core/otg/sources/otg; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/drivers/src/gpio; ../../../../../../../../platform/drivers/src/pit; ../../../../../../../../platform/drivers/src/edma; ../../../../../../../../platform/system/inc; ../../../../../../../../rtos/mqx/config/mcu/mk60d100m; ../../../../../../../../rtos/mqx/config/board/twrk60d100m; ../../../../../../../../boards/common/phyksz8041; ../../../../../../../../platform/startup/MK60D10; ../../../../../../../../platform/system/inc; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/startup; ../../../../../../../../rtos/mqx/config/common; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../boards/common/sgtl5000; ../../../../../../../../platform/drivers/src/sai; ../../../../../../../../platform/drivers/src/i2c; ../../../../../../../../platform/composite/inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk60d100m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../usb_core/device/build/iar/usbd_sdk_twrk60d100m_mqx/release/libusbd_mqx.a; ../../../../../../../../lib/ksdk_mqx_lib/iar/K60D10/release/libksdk_platform_mqx.a
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/mk60d100m/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk60d100m/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: maximum_config.h small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group board
    ../../../../../../../../boards/twrk60d100m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources/soundcard
    ../../../../../../../../platform/composite/inc/: fsl_soundcard.h
    ../../../../../../../../platform/composite/src/soundcard/: fsl_soundcard.c
  group sources/codec
    ../../../../../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
