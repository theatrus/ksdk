# Keil uVision project dev_audio_speaker_twrk22f120m_ucosiii.uvproj, settings and files
target dev_audio_speaker_twrk22f120m_ucosiii Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: dev_audio_speaker_ucosiii.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_UCOSIII
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../../../../../platform/osa/inc;../../../../../../../../rtos;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK22F51212;../../../../../../../../boards/twrk22f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../generator;../../..;../../../../../cdc/virtual_com;../../../../../composite/hid_audio;../../../../../composite/msd_cdc;../../../../../hid/hid_keyboard;../../../../../hid/hid_mouse;../../../../../msd;../../../../../phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/twrk22f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk22f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/drivers/src/gpio;../../../../../../../../platform/drivers/src/pit;../../../../../../../../platform/drivers/src/edma;../../../../../../../../platform/drivers/src/lpuart;../../../../../../../../platform/system/inc;../../../../../../../../rtos/uCOSIII/src/config;../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../../../../../rtos/uCOSIII/src/uC-CPU;../../../../../../../../rtos/uCOSIII/src/uC-LIB;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers/src/sai;../../../../../../../../platform/drivers/src/i2c;../../../../../../../../platform/composite/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/linker/MK22F51212/arm/MK22FN512xxx12_flash.scf
  link misc: ../../../../../../../usb_core/device/build/mdk/usbd_sdk_twrk22f120m_ucosiii/debug/libusbd_ucosiii.lib 
../../../../../../../../lib/ksdk_ucosiii_lib/mdk/K22F51212/debug/libksdk_platform_ucosiii.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
  group ucosiii
    ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
    ../../../../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.s
    ../../../../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../platform/startup/MK22F51212/arm/: startup_MK22F51212.s
    ../../../../../../../../platform/startup/MK22F51212/: system_MK22F51212.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group board
    ../../../../../../../../boards/twrk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources:soundcard
    ../../../../../../../../platform/composite/inc/: fsl_soundcard.h
    ../../../../../../../../platform/composite/src/soundcard/: fsl_soundcard.c
  group sources:codec
    ../../../../../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
target dev_audio_speaker_twrk22f120m_ucosiii Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: dev_audio_speaker_ucosiii.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VDC12, KEIL, TWR_K22F120M, TOWER, FSL_RTOS_UCOSIII
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../usb_core/device/build/mdk/usbd_sdk_twrk22f120m_ucosiii/release/libusbd_ucosiii.lib 
../../../../../../../../lib/ksdk_ucosiii_lib/mdk/K22F51212/release/libksdk_platform_ucosiii.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
