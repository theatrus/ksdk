# Keil uVision project dev_audio_speaker_twrk64f120m_freertos.uvproj, settings and files
target dev_audio_speaker_twrk64f120m_freertos Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: dev_audio_speaker_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER, FSL_RTOS_FREE_RTOS
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../../rtos/FreeRTOS/config/K64F12/mdk;../../../../../../../../rtos/FreeRTOS/port/mdk;../../../../../../../../platform/osa/inc;../../../../../../../../rtos;../../../../../../../../platform/utilities/inc;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/CMSIS/Include/device;../../../../../../../../platform/startup/MK64F12;../../../../../../../../boards/twrk64f120m;../../../../../../../adapter/sources;../../../../../../../adapter/sources/sdk;../../../../generator;../../..;../../../../../cdc/virtual_com;../../../../../composite/hid_audio;../../../../../composite/msd_cdc;../../../../../hid/hid_keyboard;../../../../../hid/hid_mouse;../../../../../msd;../../../../../phdc/weighscale;../../../../../../host/audio/speaker;../../../../../../host/cdc/cdc_serial;../../../../../../host/cdc/cdc_serial/sdk/serial_bsp;../../../../../../host/hid/keyboard;../../../../../../host/hid/keyboard+mouse;../../../../../../host/hid/mouse;../../../../../../host/msd/msd_cmd;../../../../../../host/phdc/11073Manager_Demo;../../../../../../otg/hid/mouse;../../../../../../../usb_core/device/include/twrk64f120m;../../../../../../../usb_core/device/include;../../../../../../../usb_core/device/sources/classes/audio;../../../../../../../usb_core/device/sources/classes/cdc;../../../../../../../usb_core/device/sources/classes/common;../../../../../../../usb_core/device/sources/classes/composite;../../../../../../../usb_core/device/sources/classes/hid;../../../../../../../usb_core/device/sources/classes/include;../../../../../../../usb_core/device/sources/classes/msd;../../../../../../../usb_core/device/sources/classes/phdc;../../../../../../../usb_core/device/sources/controller/khci;../../../../../../../usb_core/device/sources/controller;../../../../../../../usb_core/hal;../../../../../../../usb_core/host/include/twrk64f120m;../../../../../../../usb_core/host/include;../../../../../../../usb_core/host/sources/classes/audio;../../../../../../../usb_core/host/sources/classes/cdc;../../../../../../../usb_core/host/sources/classes/hid;../../../../../../../usb_core/host/sources/classes/hub;../../../../../../../usb_core/host/sources/classes/msd;../../../../../../../usb_core/host/sources/classes/phdc;../../../../../../../usb_core/host/sources/classes/printer;../../../../../../../usb_core/host/sources/controller/khci;../../../../../../../usb_core/host/sources/controller;../../../../../../../usb_core/include;../../../../../../../usb_core/otg/sources/driver/khci;../../../../../../../usb_core/otg/sources/driver/max3353/sdk;../../../../../../../usb_core/otg/sources/include;../../../../../../../usb_core/otg/sources/otg;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/drivers/src/gpio;../../../../../../../../platform/drivers/src/pit;../../../../../../../../platform/drivers/src/edma;../../../../../../../../platform/system/inc;../../../../../../../../rtos/FreeRTOS/include;../../../../../../../../rtos/FreeRTOS/src;../../../../../../../../boards/common/sgtl5000;../../../../../../../../platform/drivers/src/sai;../../../../../../../../platform/drivers/src/i2c;../../../../../../../../platform/composite/inc
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../rtos/FreeRTOS/config/K64F12/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../../../../platform/linker/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../../../usb_core/device/build/mdk/usbd_sdk_twrk64f120m_freertos/debug/libusbd_freertos.lib 
../../../../../../../../lib/ksdk_freertos_lib/mdk/K64F12/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
  group free-rtos
    ../../../../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../../../../../platform/startup/: startup.c startup.h
  group board
    ../../../../../../../../boards/twrk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
  group sources
    ../../../: usb_request.h usb_request.c usb_descriptor.h usb_descriptor.c audio_speaker.h audio_speaker.c
  group sources:soundcard
    ../../../../../../../../platform/composite/inc/: fsl_soundcard.h
    ../../../../../../../../platform/composite/src/soundcard/: fsl_soundcard.c
  group sources:codec
    ../../../../../../../../boards/common/sgtl5000/src/: fsl_sgtl5000_driver.c
    ../../../../../../../../boards/common/sgtl5000/: fsl_sgtl5000_driver.h
target dev_audio_speaker_twrk64f120m_freertos Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: dev_audio_speaker_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, TWR_K64F120M, TOWER, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../../rtos/FreeRTOS/config/K64F12/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../../../usb_core/device/build/mdk/usbd_sdk_twrk64f120m_freertos/release/libusbd_freertos.lib 
../../../../../../../../lib/ksdk_freertos_lib/mdk/K64F12/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__ram_vector_table__=1" 
--predefine="-D__stack_size__=0x4000" 
--predefine="-D__heap_size__=0x8000"
